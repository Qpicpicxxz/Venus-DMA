*
* Copyright (c) 1993 - 2024 ARM. All Rights Reserved
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of ARM,
* and is protected by patents, copyright law
* and international treaties
*
* Generated by bif2cdl 3.9.2
* Version: r1p1
* Name: High Density Dual Port SRAM RVT RVT Compiler | LOGIC0040LL 40nm Process 0.589um^2 Bit Cell
* Comment:
* Configuration:  -activity_factor 50 -back_biasing off -bits 64 -b\
* Configuration: mux on -bus_notation on -check_instname on -diodes\
* Configuration:  on -drive 6 -ema on -frequency 1.0 -instname SRAM\
* Configuration: dpw64d256 -left_bus_delim "[" -mux 4 -mvt "" -name\
* Configuration: _case upper -power_type otc -prefix "" -pwr_gnd_re\
* Configuration: name vddpe:VDDPE,vddce:VDDCE,vsse:VSSE -retention \
* Configuration: on -right_bus_delim "]" -rows_p_bl 256 -ser none -\
* Configuration: site_def off -top_layer m5-m10 -words 256 -write_m\
* Configuration: ask off -write_thru off -corners ff_1p21v_1p21v_0c\
* Configuration: ,ff_1p21v_1p21v_125c,ff_1p21v_1p21v_m40c,ss_0p99v_\
* Configuration: 0p99v_0c,ss_0p99v_0p99v_125c,ss_0p99v_0p99v_m40c,t\
* Configuration: t_1p10v_1p10v_125c,tt_1p10v_1p10v_25c,tt_1p10v_1p1\
* Configuration: 0v_85c
* Codefile:
*
*
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT SRAMdpw64d256CCCAP4 BIT_A[0] BIT_A[1] BIT_A[2] BIT_A[3] BIT_B[0]
+  BIT_B[1] BIT_B[2] BIT_B[3] DATAIN_A DATAIN_B GDL_A GDL_B NBIT_A[0]
+  NBIT_A[1] NBIT_A[2] NBIT_A[3] NBIT_B[0] NBIT_B[1] NBIT_B[2] NBIT_B[3]
+  NWGSEL_A NWGSEL_B VDDC VDDCE VDDPE VNWC VPW VSSE
** SRAMdpw64d256CCCAP4: 48 flat devices **
X_MXN1 VPW NET0111 NET0154 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN12 NET0128 VPW BIT_B[3] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN14 NET0124 VPW BIT_B[2] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN15 NBIT_B[3] VPW NET0121 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN16 NBIT_B[2] VPW NET0117 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN18 NBIT_B[0] VPW NET055 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN26 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN27 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN28 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN29 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN30 VPW VPW NET130 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN31 VPW VPW NET134 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN32 VPW VPW NET138 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN33 VPW VPW NET142 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN4 NET0161 NET0163 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN40 NET053 NET0143 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN41 VPW NET095 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN42 VPW NET087 NET0134 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN43 VPW NET083 NET0146 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN44 VPW NET0103 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN45 NET054 NET0151 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN46 NET052 NET0119 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN47 VPW NET071 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN48 VPW NET079 NET0122 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN49 NET0176 VPW BIT_B[0] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN50 NBIT_B[1] VPW NET0173 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN51 NET0168 VPW BIT_B[1] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN52 VPW VPW NET0153 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN53 VPW VPW NET0149 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN54 VPW VPW NET0145 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN55 VPW VPW NET0141 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN56 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN57 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN58 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN59 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXNpdl VPW NET0107 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXP1 NET0110 NET0111 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP11 NET090 NET0143 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP12 VNWC NET095 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP13 NET086 NET087 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP14 NET082 NET083 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP15 VNWC NET0103 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP16 NET098 NET0151 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP17 NET074 NET0119 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP18 VNWC NET071 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP19 NET078 NET079 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP4 VNWC NET0107 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP9 NET0114 NET0163 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS SRAMdpw64d256CCCAP4
****
.SUBCKT SRAMdpw64d256CCICD032O BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3
+  BIT_A[0]_4 BIT_A[0]_5 BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9
+  BIT_A[0]_10 BIT_A[0]_11 BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15
+  BIT_A[0]_16 BIT_A[0]_17 BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21
+  BIT_A[0]_22 BIT_A[0]_23 BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27
+  BIT_A[0]_28 BIT_A[0]_29 BIT_A[0]_30 BIT_A[0]_31 BIT_A[1]_0 BIT_A[1]_1
+  BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6 BIT_A[1]_7
+  BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12 BIT_A[1]_13
+  BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18 BIT_A[1]_19
+  BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24 BIT_A[1]_25
+  BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30 BIT_A[1]_31
+  BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2 BIT_A[2]_3 BIT_A[2]_4 BIT_A[2]_5
+  BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8 BIT_A[2]_9 BIT_A[2]_10 BIT_A[2]_11
+  BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14 BIT_A[2]_15 BIT_A[2]_16 BIT_A[2]_17
+  BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20 BIT_A[2]_21 BIT_A[2]_22 BIT_A[2]_23
+  BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26 BIT_A[2]_27 BIT_A[2]_28 BIT_A[2]_29
+  BIT_A[2]_30 BIT_A[2]_31 BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3
+  BIT_A[3]_4 BIT_A[3]_5 BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9
+  BIT_A[3]_10 BIT_A[3]_11 BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15
+  BIT_A[3]_16 BIT_A[3]_17 BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21
+  BIT_A[3]_22 BIT_A[3]_23 BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27
+  BIT_A[3]_28 BIT_A[3]_29 BIT_A[3]_30 BIT_A[3]_31 BIT_B[0]_0 BIT_B[0]_1
+  BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6 BIT_B[0]_7
+  BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12 BIT_B[0]_13
+  BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18 BIT_B[0]_19
+  BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24 BIT_B[0]_25
+  BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30 BIT_B[0]_31
+  BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2 BIT_B[1]_3 BIT_B[1]_4 BIT_B[1]_5
+  BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8 BIT_B[1]_9 BIT_B[1]_10 BIT_B[1]_11
+  BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14 BIT_B[1]_15 BIT_B[1]_16 BIT_B[1]_17
+  BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20 BIT_B[1]_21 BIT_B[1]_22 BIT_B[1]_23
+  BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26 BIT_B[1]_27 BIT_B[1]_28 BIT_B[1]_29
+  BIT_B[1]_30 BIT_B[1]_31 BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3
+  BIT_B[2]_4 BIT_B[2]_5 BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9
+  BIT_B[2]_10 BIT_B[2]_11 BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15
+  BIT_B[2]_16 BIT_B[2]_17 BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21
+  BIT_B[2]_22 BIT_B[2]_23 BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27
+  BIT_B[2]_28 BIT_B[2]_29 BIT_B[2]_30 BIT_B[2]_31 BIT_B[3]_0 BIT_B[3]_1
+  BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6 BIT_B[3]_7
+  BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12 BIT_B[3]_13
+  BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18 BIT_B[3]_19
+  BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24 BIT_B[3]_25
+  BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30 BIT_B[3]_31
+  DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5
+  DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11
+  DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17
+  DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23
+  DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29
+  DATAIN_A_30 DATAIN_A_31 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3
+  DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9
+  DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15
+  DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21
+  DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27
+  DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 GDL_A_0 GDL_A_1 GDL_A_2
+  GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11
+  GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19
+  GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27
+  GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4
+  GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13
+  GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21
+  GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29
+  GDL_B_30 GDL_B_31 NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2 NBIT_A[0]_3
+  NBIT_A[0]_4 NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8 NBIT_A[0]_9
+  NBIT_A[0]_10 NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13 NBIT_A[0]_14
+  NBIT_A[0]_15 NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18 NBIT_A[0]_19
+  NBIT_A[0]_20 NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23 NBIT_A[0]_24
+  NBIT_A[0]_25 NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28 NBIT_A[0]_29
+  NBIT_A[0]_30 NBIT_A[0]_31 NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2 NBIT_A[1]_3
+  NBIT_A[1]_4 NBIT_A[1]_5 NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8 NBIT_A[1]_9
+  NBIT_A[1]_10 NBIT_A[1]_11 NBIT_A[1]_12 NBIT_A[1]_13 NBIT_A[1]_14
+  NBIT_A[1]_15 NBIT_A[1]_16 NBIT_A[1]_17 NBIT_A[1]_18 NBIT_A[1]_19
+  NBIT_A[1]_20 NBIT_A[1]_21 NBIT_A[1]_22 NBIT_A[1]_23 NBIT_A[1]_24
+  NBIT_A[1]_25 NBIT_A[1]_26 NBIT_A[1]_27 NBIT_A[1]_28 NBIT_A[1]_29
+  NBIT_A[1]_30 NBIT_A[1]_31 NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3
+  NBIT_A[2]_4 NBIT_A[2]_5 NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9
+  NBIT_A[2]_10 NBIT_A[2]_11 NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14
+  NBIT_A[2]_15 NBIT_A[2]_16 NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19
+  NBIT_A[2]_20 NBIT_A[2]_21 NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24
+  NBIT_A[2]_25 NBIT_A[2]_26 NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29
+  NBIT_A[2]_30 NBIT_A[2]_31 NBIT_A[3]_0 NBIT_A[3]_1 NBIT_A[3]_2 NBIT_A[3]_3
+  NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7 NBIT_A[3]_8 NBIT_A[3]_9
+  NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13 NBIT_A[3]_14
+  NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18 NBIT_A[3]_19
+  NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23 NBIT_A[3]_24
+  NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28 NBIT_A[3]_29
+  NBIT_A[3]_30 NBIT_A[3]_31 NBIT_B[0]_0 NBIT_B[0]_1 NBIT_B[0]_2 NBIT_B[0]_3
+  NBIT_B[0]_4 NBIT_B[0]_5 NBIT_B[0]_6 NBIT_B[0]_7 NBIT_B[0]_8 NBIT_B[0]_9
+  NBIT_B[0]_10 NBIT_B[0]_11 NBIT_B[0]_12 NBIT_B[0]_13 NBIT_B[0]_14
+  NBIT_B[0]_15 NBIT_B[0]_16 NBIT_B[0]_17 NBIT_B[0]_18 NBIT_B[0]_19
+  NBIT_B[0]_20 NBIT_B[0]_21 NBIT_B[0]_22 NBIT_B[0]_23 NBIT_B[0]_24
+  NBIT_B[0]_25 NBIT_B[0]_26 NBIT_B[0]_27 NBIT_B[0]_28 NBIT_B[0]_29
+  NBIT_B[0]_30 NBIT_B[0]_31 NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3
+  NBIT_B[1]_4 NBIT_B[1]_5 NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9
+  NBIT_B[1]_10 NBIT_B[1]_11 NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14
+  NBIT_B[1]_15 NBIT_B[1]_16 NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19
+  NBIT_B[1]_20 NBIT_B[1]_21 NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24
+  NBIT_B[1]_25 NBIT_B[1]_26 NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29
+  NBIT_B[1]_30 NBIT_B[1]_31 NBIT_B[2]_0 NBIT_B[2]_1 NBIT_B[2]_2 NBIT_B[2]_3
+  NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7 NBIT_B[2]_8 NBIT_B[2]_9
+  NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13 NBIT_B[2]_14
+  NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18 NBIT_B[2]_19
+  NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23 NBIT_B[2]_24
+  NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28 NBIT_B[2]_29
+  NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[3]_0 NBIT_B[3]_1 NBIT_B[3]_2 NBIT_B[3]_3
+  NBIT_B[3]_4 NBIT_B[3]_5 NBIT_B[3]_6 NBIT_B[3]_7 NBIT_B[3]_8 NBIT_B[3]_9
+  NBIT_B[3]_10 NBIT_B[3]_11 NBIT_B[3]_12 NBIT_B[3]_13 NBIT_B[3]_14
+  NBIT_B[3]_15 NBIT_B[3]_16 NBIT_B[3]_17 NBIT_B[3]_18 NBIT_B[3]_19
+  NBIT_B[3]_20 NBIT_B[3]_21 NBIT_B[3]_22 NBIT_B[3]_23 NBIT_B[3]_24
+  NBIT_B[3]_25 NBIT_B[3]_26 NBIT_B[3]_27 NBIT_B[3]_28 NBIT_B[3]_29
+  NBIT_B[3]_30 NBIT_B[3]_31 NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3
+  NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9
+  NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15
+  NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21
+  NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27
+  NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_B_0 NWGSEL_B_1
+  NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7
+  NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13
+  NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19
+  NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25
+  NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31
+  VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VPW
** SRAMdpw64d256CCICD032O: 1536 flat devices **
XCCCAP4LSB0 BIT_A[0]_31 BIT_A[1]_31 BIT_A[2]_31 BIT_A[3]_31 BIT_B[0]_31
+  BIT_B[1]_31 BIT_B[2]_31 BIT_B[3]_31 DATAIN_A_31 DATAIN_B_31 GDL_A_31
+  GDL_B_31 NBIT_A[0]_31 NBIT_A[1]_31 NBIT_A[2]_31 NBIT_A[3]_31 NBIT_B[0]_31
+  NBIT_B[1]_31 NBIT_B[2]_31 NBIT_B[3]_31 NWGSEL_A_31 NWGSEL_B_31 VDDC VDDC
+  VDDPE_31 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4LSB1 BIT_A[0]_30 BIT_A[1]_30 BIT_A[2]_30 BIT_A[3]_30 BIT_B[0]_30
+  BIT_B[1]_30 BIT_B[2]_30 BIT_B[3]_30 DATAIN_A_30 DATAIN_B_30 GDL_A_30
+  GDL_B_30 NBIT_A[0]_30 NBIT_A[1]_30 NBIT_A[2]_30 NBIT_A[3]_30 NBIT_B[0]_30
+  NBIT_B[1]_30 NBIT_B[2]_30 NBIT_B[3]_30 NWGSEL_A_30 NWGSEL_B_30 VDDC VDDC
+  VDDPE_30 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4LSB2 BIT_A[0]_29 BIT_A[1]_29 BIT_A[2]_29 BIT_A[3]_29 BIT_B[0]_29
+  BIT_B[1]_29 BIT_B[2]_29 BIT_B[3]_29 DATAIN_A_29 DATAIN_B_29 GDL_A_29
+  GDL_B_29 NBIT_A[0]_29 NBIT_A[1]_29 NBIT_A[2]_29 NBIT_A[3]_29 NBIT_B[0]_29
+  NBIT_B[1]_29 NBIT_B[2]_29 NBIT_B[3]_29 NWGSEL_A_29 NWGSEL_B_29 VDDC VDDC
+  VDDPE_29 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4LSB3 BIT_A[0]_28 BIT_A[1]_28 BIT_A[2]_28 BIT_A[3]_28 BIT_B[0]_28
+  BIT_B[1]_28 BIT_B[2]_28 BIT_B[3]_28 DATAIN_A_28 DATAIN_B_28 GDL_A_28
+  GDL_B_28 NBIT_A[0]_28 NBIT_A[1]_28 NBIT_A[2]_28 NBIT_A[3]_28 NBIT_B[0]_28
+  NBIT_B[1]_28 NBIT_B[2]_28 NBIT_B[3]_28 NWGSEL_A_28 NWGSEL_B_28 VDDC VDDC
+  VDDPE_28 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4MSB0 BIT_A[0]_3 BIT_A[1]_3 BIT_A[2]_3 BIT_A[3]_3 BIT_B[0]_3 BIT_B[1]_3
+  BIT_B[2]_3 BIT_B[3]_3 DATAIN_A_3 DATAIN_B_3 GDL_A_3 GDL_B_3 NBIT_A[0]_3
+  NBIT_A[1]_3 NBIT_A[2]_3 NBIT_A[3]_3 NBIT_B[0]_3 NBIT_B[1]_3 NBIT_B[2]_3
+  NBIT_B[3]_3 NWGSEL_A_3 NWGSEL_B_3 VDDC VDDC VDDPE_3 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4MSB1 BIT_A[0]_2 BIT_A[1]_2 BIT_A[2]_2 BIT_A[3]_2 BIT_B[0]_2 BIT_B[1]_2
+  BIT_B[2]_2 BIT_B[3]_2 DATAIN_A_2 DATAIN_B_2 GDL_A_2 GDL_B_2 NBIT_A[0]_2
+  NBIT_A[1]_2 NBIT_A[2]_2 NBIT_A[3]_2 NBIT_B[0]_2 NBIT_B[1]_2 NBIT_B[2]_2
+  NBIT_B[3]_2 NWGSEL_A_2 NWGSEL_B_2 VDDC VDDC VDDPE_2 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4MSB2 BIT_A[0]_1 BIT_A[1]_1 BIT_A[2]_1 BIT_A[3]_1 BIT_B[0]_1 BIT_B[1]_1
+  BIT_B[2]_1 BIT_B[3]_1 DATAIN_A_1 DATAIN_B_1 GDL_A_1 GDL_B_1 NBIT_A[0]_1
+  NBIT_A[1]_1 NBIT_A[2]_1 NBIT_A[3]_1 NBIT_B[0]_1 NBIT_B[1]_1 NBIT_B[2]_1
+  NBIT_B[3]_1 NWGSEL_A_1 NWGSEL_B_1 VDDC VDDC VDDPE_1 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4MSB3 BIT_A[0]_0 BIT_A[1]_0 BIT_A[2]_0 BIT_A[3]_0 BIT_B[0]_0 BIT_B[1]_0
+  BIT_B[2]_0 BIT_B[3]_0 DATAIN_A_0 DATAIN_B_0 GDL_A_0 GDL_B_0 NBIT_A[0]_0
+  NBIT_A[1]_0 NBIT_A[2]_0 NBIT_A[3]_0 NBIT_B[0]_0 NBIT_B[1]_0 NBIT_B[2]_0
+  NBIT_B[3]_0 NWGSEL_A_0 NWGSEL_B_0 VDDC VDDC VDDPE_0 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[10] BIT_A[0]_21 BIT_A[1]_21 BIT_A[2]_21 BIT_A[3]_21 BIT_B[0]_21
+  BIT_B[1]_21 BIT_B[2]_21 BIT_B[3]_21 DATAIN_A_21 DATAIN_B_21 GDL_A_21
+  GDL_B_21 NBIT_A[0]_21 NBIT_A[1]_21 NBIT_A[2]_21 NBIT_A[3]_21 NBIT_B[0]_21
+  NBIT_B[1]_21 NBIT_B[2]_21 NBIT_B[3]_21 NWGSEL_A_21 NWGSEL_B_21 VDDC VDDC
+  VDDPE_21 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[11] BIT_A[0]_20 BIT_A[1]_20 BIT_A[2]_20 BIT_A[3]_20 BIT_B[0]_20
+  BIT_B[1]_20 BIT_B[2]_20 BIT_B[3]_20 DATAIN_A_20 DATAIN_B_20 GDL_A_20
+  GDL_B_20 NBIT_A[0]_20 NBIT_A[1]_20 NBIT_A[2]_20 NBIT_A[3]_20 NBIT_B[0]_20
+  NBIT_B[1]_20 NBIT_B[2]_20 NBIT_B[3]_20 NWGSEL_A_20 NWGSEL_B_20 VDDC VDDC
+  VDDPE_20 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[12] BIT_A[0]_19 BIT_A[1]_19 BIT_A[2]_19 BIT_A[3]_19 BIT_B[0]_19
+  BIT_B[1]_19 BIT_B[2]_19 BIT_B[3]_19 DATAIN_A_19 DATAIN_B_19 GDL_A_19
+  GDL_B_19 NBIT_A[0]_19 NBIT_A[1]_19 NBIT_A[2]_19 NBIT_A[3]_19 NBIT_B[0]_19
+  NBIT_B[1]_19 NBIT_B[2]_19 NBIT_B[3]_19 NWGSEL_A_19 NWGSEL_B_19 VDDC VDDC
+  VDDPE_19 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[13] BIT_A[0]_18 BIT_A[1]_18 BIT_A[2]_18 BIT_A[3]_18 BIT_B[0]_18
+  BIT_B[1]_18 BIT_B[2]_18 BIT_B[3]_18 DATAIN_A_18 DATAIN_B_18 GDL_A_18
+  GDL_B_18 NBIT_A[0]_18 NBIT_A[1]_18 NBIT_A[2]_18 NBIT_A[3]_18 NBIT_B[0]_18
+  NBIT_B[1]_18 NBIT_B[2]_18 NBIT_B[3]_18 NWGSEL_A_18 NWGSEL_B_18 VDDC VDDC
+  VDDPE_18 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[14] BIT_A[0]_17 BIT_A[1]_17 BIT_A[2]_17 BIT_A[3]_17 BIT_B[0]_17
+  BIT_B[1]_17 BIT_B[2]_17 BIT_B[3]_17 DATAIN_A_17 DATAIN_B_17 GDL_A_17
+  GDL_B_17 NBIT_A[0]_17 NBIT_A[1]_17 NBIT_A[2]_17 NBIT_A[3]_17 NBIT_B[0]_17
+  NBIT_B[1]_17 NBIT_B[2]_17 NBIT_B[3]_17 NWGSEL_A_17 NWGSEL_B_17 VDDC VDDC
+  VDDPE_17 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[15] BIT_A[0]_16 BIT_A[1]_16 BIT_A[2]_16 BIT_A[3]_16 BIT_B[0]_16
+  BIT_B[1]_16 BIT_B[2]_16 BIT_B[3]_16 DATAIN_A_16 DATAIN_B_16 GDL_A_16
+  GDL_B_16 NBIT_A[0]_16 NBIT_A[1]_16 NBIT_A[2]_16 NBIT_A[3]_16 NBIT_B[0]_16
+  NBIT_B[1]_16 NBIT_B[2]_16 NBIT_B[3]_16 NWGSEL_A_16 NWGSEL_B_16 VDDC VDDC
+  VDDPE_16 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[16] BIT_A[0]_15 BIT_A[1]_15 BIT_A[2]_15 BIT_A[3]_15 BIT_B[0]_15
+  BIT_B[1]_15 BIT_B[2]_15 BIT_B[3]_15 DATAIN_A_15 DATAIN_B_15 GDL_A_15
+  GDL_B_15 NBIT_A[0]_15 NBIT_A[1]_15 NBIT_A[2]_15 NBIT_A[3]_15 NBIT_B[0]_15
+  NBIT_B[1]_15 NBIT_B[2]_15 NBIT_B[3]_15 NWGSEL_A_15 NWGSEL_B_15 VDDC VDDC
+  VDDPE_15 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[17] BIT_A[0]_14 BIT_A[1]_14 BIT_A[2]_14 BIT_A[3]_14 BIT_B[0]_14
+  BIT_B[1]_14 BIT_B[2]_14 BIT_B[3]_14 DATAIN_A_14 DATAIN_B_14 GDL_A_14
+  GDL_B_14 NBIT_A[0]_14 NBIT_A[1]_14 NBIT_A[2]_14 NBIT_A[3]_14 NBIT_B[0]_14
+  NBIT_B[1]_14 NBIT_B[2]_14 NBIT_B[3]_14 NWGSEL_A_14 NWGSEL_B_14 VDDC VDDC
+  VDDPE_14 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[18] BIT_A[0]_13 BIT_A[1]_13 BIT_A[2]_13 BIT_A[3]_13 BIT_B[0]_13
+  BIT_B[1]_13 BIT_B[2]_13 BIT_B[3]_13 DATAIN_A_13 DATAIN_B_13 GDL_A_13
+  GDL_B_13 NBIT_A[0]_13 NBIT_A[1]_13 NBIT_A[2]_13 NBIT_A[3]_13 NBIT_B[0]_13
+  NBIT_B[1]_13 NBIT_B[2]_13 NBIT_B[3]_13 NWGSEL_A_13 NWGSEL_B_13 VDDC VDDC
+  VDDPE_13 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[19] BIT_A[0]_12 BIT_A[1]_12 BIT_A[2]_12 BIT_A[3]_12 BIT_B[0]_12
+  BIT_B[1]_12 BIT_B[2]_12 BIT_B[3]_12 DATAIN_A_12 DATAIN_B_12 GDL_A_12
+  GDL_B_12 NBIT_A[0]_12 NBIT_A[1]_12 NBIT_A[2]_12 NBIT_A[3]_12 NBIT_B[0]_12
+  NBIT_B[1]_12 NBIT_B[2]_12 NBIT_B[3]_12 NWGSEL_A_12 NWGSEL_B_12 VDDC VDDC
+  VDDPE_12 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[20] BIT_A[0]_11 BIT_A[1]_11 BIT_A[2]_11 BIT_A[3]_11 BIT_B[0]_11
+  BIT_B[1]_11 BIT_B[2]_11 BIT_B[3]_11 DATAIN_A_11 DATAIN_B_11 GDL_A_11
+  GDL_B_11 NBIT_A[0]_11 NBIT_A[1]_11 NBIT_A[2]_11 NBIT_A[3]_11 NBIT_B[0]_11
+  NBIT_B[1]_11 NBIT_B[2]_11 NBIT_B[3]_11 NWGSEL_A_11 NWGSEL_B_11 VDDC VDDC
+  VDDPE_11 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[21] BIT_A[0]_10 BIT_A[1]_10 BIT_A[2]_10 BIT_A[3]_10 BIT_B[0]_10
+  BIT_B[1]_10 BIT_B[2]_10 BIT_B[3]_10 DATAIN_A_10 DATAIN_B_10 GDL_A_10
+  GDL_B_10 NBIT_A[0]_10 NBIT_A[1]_10 NBIT_A[2]_10 NBIT_A[3]_10 NBIT_B[0]_10
+  NBIT_B[1]_10 NBIT_B[2]_10 NBIT_B[3]_10 NWGSEL_A_10 NWGSEL_B_10 VDDC VDDC
+  VDDPE_10 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[22] BIT_A[0]_9 BIT_A[1]_9 BIT_A[2]_9 BIT_A[3]_9 BIT_B[0]_9 BIT_B[1]_9
+  BIT_B[2]_9 BIT_B[3]_9 DATAIN_A_9 DATAIN_B_9 GDL_A_9 GDL_B_9 NBIT_A[0]_9
+  NBIT_A[1]_9 NBIT_A[2]_9 NBIT_A[3]_9 NBIT_B[0]_9 NBIT_B[1]_9 NBIT_B[2]_9
+  NBIT_B[3]_9 NWGSEL_A_9 NWGSEL_B_9 VDDC VDDC VDDPE_9 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[23] BIT_A[0]_8 BIT_A[1]_8 BIT_A[2]_8 BIT_A[3]_8 BIT_B[0]_8 BIT_B[1]_8
+  BIT_B[2]_8 BIT_B[3]_8 DATAIN_A_8 DATAIN_B_8 GDL_A_8 GDL_B_8 NBIT_A[0]_8
+  NBIT_A[1]_8 NBIT_A[2]_8 NBIT_A[3]_8 NBIT_B[0]_8 NBIT_B[1]_8 NBIT_B[2]_8
+  NBIT_B[3]_8 NWGSEL_A_8 NWGSEL_B_8 VDDC VDDC VDDPE_8 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[24] BIT_A[0]_7 BIT_A[1]_7 BIT_A[2]_7 BIT_A[3]_7 BIT_B[0]_7 BIT_B[1]_7
+  BIT_B[2]_7 BIT_B[3]_7 DATAIN_A_7 DATAIN_B_7 GDL_A_7 GDL_B_7 NBIT_A[0]_7
+  NBIT_A[1]_7 NBIT_A[2]_7 NBIT_A[3]_7 NBIT_B[0]_7 NBIT_B[1]_7 NBIT_B[2]_7
+  NBIT_B[3]_7 NWGSEL_A_7 NWGSEL_B_7 VDDC VDDC VDDPE_7 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[25] BIT_A[0]_6 BIT_A[1]_6 BIT_A[2]_6 BIT_A[3]_6 BIT_B[0]_6 BIT_B[1]_6
+  BIT_B[2]_6 BIT_B[3]_6 DATAIN_A_6 DATAIN_B_6 GDL_A_6 GDL_B_6 NBIT_A[0]_6
+  NBIT_A[1]_6 NBIT_A[2]_6 NBIT_A[3]_6 NBIT_B[0]_6 NBIT_B[1]_6 NBIT_B[2]_6
+  NBIT_B[3]_6 NWGSEL_A_6 NWGSEL_B_6 VDDC VDDC VDDPE_6 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[26] BIT_A[0]_5 BIT_A[1]_5 BIT_A[2]_5 BIT_A[3]_5 BIT_B[0]_5 BIT_B[1]_5
+  BIT_B[2]_5 BIT_B[3]_5 DATAIN_A_5 DATAIN_B_5 GDL_A_5 GDL_B_5 NBIT_A[0]_5
+  NBIT_A[1]_5 NBIT_A[2]_5 NBIT_A[3]_5 NBIT_B[0]_5 NBIT_B[1]_5 NBIT_B[2]_5
+  NBIT_B[3]_5 NWGSEL_A_5 NWGSEL_B_5 VDDC VDDC VDDPE_5 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[27] BIT_A[0]_4 BIT_A[1]_4 BIT_A[2]_4 BIT_A[3]_4 BIT_B[0]_4 BIT_B[1]_4
+  BIT_B[2]_4 BIT_B[3]_4 DATAIN_A_4 DATAIN_B_4 GDL_A_4 GDL_B_4 NBIT_A[0]_4
+  NBIT_A[1]_4 NBIT_A[2]_4 NBIT_A[3]_4 NBIT_B[0]_4 NBIT_B[1]_4 NBIT_B[2]_4
+  NBIT_B[3]_4 NWGSEL_A_4 NWGSEL_B_4 VDDC VDDC VDDPE_4 VDDC VPW VPW
+  SRAMdpw64d256CCCAP4
XCCCAP4[4] BIT_A[0]_27 BIT_A[1]_27 BIT_A[2]_27 BIT_A[3]_27 BIT_B[0]_27
+  BIT_B[1]_27 BIT_B[2]_27 BIT_B[3]_27 DATAIN_A_27 DATAIN_B_27 GDL_A_27
+  GDL_B_27 NBIT_A[0]_27 NBIT_A[1]_27 NBIT_A[2]_27 NBIT_A[3]_27 NBIT_B[0]_27
+  NBIT_B[1]_27 NBIT_B[2]_27 NBIT_B[3]_27 NWGSEL_A_27 NWGSEL_B_27 VDDC VDDC
+  VDDPE_27 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[5] BIT_A[0]_26 BIT_A[1]_26 BIT_A[2]_26 BIT_A[3]_26 BIT_B[0]_26
+  BIT_B[1]_26 BIT_B[2]_26 BIT_B[3]_26 DATAIN_A_26 DATAIN_B_26 GDL_A_26
+  GDL_B_26 NBIT_A[0]_26 NBIT_A[1]_26 NBIT_A[2]_26 NBIT_A[3]_26 NBIT_B[0]_26
+  NBIT_B[1]_26 NBIT_B[2]_26 NBIT_B[3]_26 NWGSEL_A_26 NWGSEL_B_26 VDDC VDDC
+  VDDPE_26 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[6] BIT_A[0]_25 BIT_A[1]_25 BIT_A[2]_25 BIT_A[3]_25 BIT_B[0]_25
+  BIT_B[1]_25 BIT_B[2]_25 BIT_B[3]_25 DATAIN_A_25 DATAIN_B_25 GDL_A_25
+  GDL_B_25 NBIT_A[0]_25 NBIT_A[1]_25 NBIT_A[2]_25 NBIT_A[3]_25 NBIT_B[0]_25
+  NBIT_B[1]_25 NBIT_B[2]_25 NBIT_B[3]_25 NWGSEL_A_25 NWGSEL_B_25 VDDC VDDC
+  VDDPE_25 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[7] BIT_A[0]_24 BIT_A[1]_24 BIT_A[2]_24 BIT_A[3]_24 BIT_B[0]_24
+  BIT_B[1]_24 BIT_B[2]_24 BIT_B[3]_24 DATAIN_A_24 DATAIN_B_24 GDL_A_24
+  GDL_B_24 NBIT_A[0]_24 NBIT_A[1]_24 NBIT_A[2]_24 NBIT_A[3]_24 NBIT_B[0]_24
+  NBIT_B[1]_24 NBIT_B[2]_24 NBIT_B[3]_24 NWGSEL_A_24 NWGSEL_B_24 VDDC VDDC
+  VDDPE_24 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[8] BIT_A[0]_23 BIT_A[1]_23 BIT_A[2]_23 BIT_A[3]_23 BIT_B[0]_23
+  BIT_B[1]_23 BIT_B[2]_23 BIT_B[3]_23 DATAIN_A_23 DATAIN_B_23 GDL_A_23
+  GDL_B_23 NBIT_A[0]_23 NBIT_A[1]_23 NBIT_A[2]_23 NBIT_A[3]_23 NBIT_B[0]_23
+  NBIT_B[1]_23 NBIT_B[2]_23 NBIT_B[3]_23 NWGSEL_A_23 NWGSEL_B_23 VDDC VDDC
+  VDDPE_23 VDDC VPW VPW SRAMdpw64d256CCCAP4
XCCCAP4[9] BIT_A[0]_22 BIT_A[1]_22 BIT_A[2]_22 BIT_A[3]_22 BIT_B[0]_22
+  BIT_B[1]_22 BIT_B[2]_22 BIT_B[3]_22 DATAIN_A_22 DATAIN_B_22 GDL_A_22
+  GDL_B_22 NBIT_A[0]_22 NBIT_A[1]_22 NBIT_A[2]_22 NBIT_A[3]_22 NBIT_B[0]_22
+  NBIT_B[1]_22 NBIT_B[2]_22 NBIT_B[3]_22 NWGSEL_A_22 NWGSEL_B_22 VDDC VDDC
+  VDDPE_22 VDDC VPW VPW SRAMdpw64d256CCCAP4
.ENDS SRAMdpw64d256CCICD032O
****
.SUBCKT SRAMdpw64d256FCWDEDGE ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BNK_A BNK_B CLK_A CLK_B DBL_A DBL_B LOG0_DBL_A
+  LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B
+  NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2]
+  NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7]
+  NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4]
+  NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1]
+  NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6]
+  NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3]
+  NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0]
+  NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1]
+  NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0]
+  RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A RE_B VDDC VDDCA1
+  VDDCA2 VDDCB1 VDDCB2 VDDCE VDDPE VNWC VNWP VPW VSSE WE_A WE_B WRA_MA WRB_MA
+  WTE_A WTE_B
** SRAMdpw64d256FCWDEDGE: 8 flat devices **
X_MXP0 VDDCB2 NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.24U L=0.04U
X_MXP1 VDDCA1 NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.24U L=0.04U
X_MXP10 RET_SHR_DEC1B[1] RETB[1] VDDPE VNWC P11LL_CKT W=3.555U L=0.04U
X_MXP4 VDDCA2 NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.225U L=0.04U
X_MXP5 VDDCB1 NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.225U L=0.04U
X_MXP6 RET_SHR_DEC1A[1] RETA[1] VDDPE VNWC P11LL_CKT W=3.57U L=0.04U
X_MXP7 RET_SHR_DEC1A[0] RETA[0] VDDPE VNWC P11LL_CKT W=3.555U L=0.04U
X_MXP9 RET_SHR_DEC1B[0] RETB[0] VDDPE VNWC P11LL_CKT W=3.57U L=0.04U
.ENDS SRAMdpw64d256FCWDEDGE
****
.SUBCKT SRAMdpw64d256CCICD32320 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3 BIT_A[0]_4
+  BIT_A[0]_5 BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9 BIT_A[0]_10
+  BIT_A[0]_11 BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15 BIT_A[0]_16
+  BIT_A[0]_17 BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21 BIT_A[0]_22
+  BIT_A[0]_23 BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27 BIT_A[0]_28
+  BIT_A[0]_29 BIT_A[0]_30 BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34
+  BIT_A[0]_35 BIT_A[0]_36 BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40
+  BIT_A[0]_41 BIT_A[0]_42 BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46
+  BIT_A[0]_47 BIT_A[0]_48 BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52
+  BIT_A[0]_53 BIT_A[0]_54 BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58
+  BIT_A[0]_59 BIT_A[0]_60 BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_0
+  BIT_A[1]_1 BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6
+  BIT_A[1]_7 BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12
+  BIT_A[1]_13 BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18
+  BIT_A[1]_19 BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24
+  BIT_A[1]_25 BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30
+  BIT_A[1]_31 BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35 BIT_A[1]_36
+  BIT_A[1]_37 BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41 BIT_A[1]_42
+  BIT_A[1]_43 BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47 BIT_A[1]_48
+  BIT_A[1]_49 BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53 BIT_A[1]_54
+  BIT_A[1]_55 BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59 BIT_A[1]_60
+  BIT_A[1]_61 BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2
+  BIT_A[2]_3 BIT_A[2]_4 BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8
+  BIT_A[2]_9 BIT_A[2]_10 BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14
+  BIT_A[2]_15 BIT_A[2]_16 BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20
+  BIT_A[2]_21 BIT_A[2]_22 BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26
+  BIT_A[2]_27 BIT_A[2]_28 BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31 BIT_A[2]_32
+  BIT_A[2]_33 BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38
+  BIT_A[2]_39 BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44
+  BIT_A[2]_45 BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50
+  BIT_A[2]_51 BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56
+  BIT_A[2]_57 BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62
+  BIT_A[2]_63 BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3 BIT_A[3]_4
+  BIT_A[3]_5 BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9 BIT_A[3]_10
+  BIT_A[3]_11 BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15 BIT_A[3]_16
+  BIT_A[3]_17 BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21 BIT_A[3]_22
+  BIT_A[3]_23 BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27 BIT_A[3]_28
+  BIT_A[3]_29 BIT_A[3]_30 BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34
+  BIT_A[3]_35 BIT_A[3]_36 BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40
+  BIT_A[3]_41 BIT_A[3]_42 BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46
+  BIT_A[3]_47 BIT_A[3]_48 BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52
+  BIT_A[3]_53 BIT_A[3]_54 BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58
+  BIT_A[3]_59 BIT_A[3]_60 BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_0
+  BIT_B[0]_1 BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6
+  BIT_B[0]_7 BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12
+  BIT_B[0]_13 BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18
+  BIT_B[0]_19 BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24
+  BIT_B[0]_25 BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30
+  BIT_B[0]_31 BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35 BIT_B[0]_36
+  BIT_B[0]_37 BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41 BIT_B[0]_42
+  BIT_B[0]_43 BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47 BIT_B[0]_48
+  BIT_B[0]_49 BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53 BIT_B[0]_54
+  BIT_B[0]_55 BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59 BIT_B[0]_60
+  BIT_B[0]_61 BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2
+  BIT_B[1]_3 BIT_B[1]_4 BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8
+  BIT_B[1]_9 BIT_B[1]_10 BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14
+  BIT_B[1]_15 BIT_B[1]_16 BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20
+  BIT_B[1]_21 BIT_B[1]_22 BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26
+  BIT_B[1]_27 BIT_B[1]_28 BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31 BIT_B[1]_32
+  BIT_B[1]_33 BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38
+  BIT_B[1]_39 BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44
+  BIT_B[1]_45 BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50
+  BIT_B[1]_51 BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56
+  BIT_B[1]_57 BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62
+  BIT_B[1]_63 BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3 BIT_B[2]_4
+  BIT_B[2]_5 BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9 BIT_B[2]_10
+  BIT_B[2]_11 BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15 BIT_B[2]_16
+  BIT_B[2]_17 BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21 BIT_B[2]_22
+  BIT_B[2]_23 BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27 BIT_B[2]_28
+  BIT_B[2]_29 BIT_B[2]_30 BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34
+  BIT_B[2]_35 BIT_B[2]_36 BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40
+  BIT_B[2]_41 BIT_B[2]_42 BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46
+  BIT_B[2]_47 BIT_B[2]_48 BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52
+  BIT_B[2]_53 BIT_B[2]_54 BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58
+  BIT_B[2]_59 BIT_B[2]_60 BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_0
+  BIT_B[3]_1 BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6
+  BIT_B[3]_7 BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12
+  BIT_B[3]_13 BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18
+  BIT_B[3]_19 BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24
+  BIT_B[3]_25 BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30
+  BIT_B[3]_31 BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35 BIT_B[3]_36
+  BIT_B[3]_37 BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41 BIT_B[3]_42
+  BIT_B[3]_43 BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47 BIT_B[3]_48
+  BIT_B[3]_49 BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53 BIT_B[3]_54
+  BIT_B[3]_55 BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59 BIT_B[3]_60
+  BIT_B[3]_61 BIT_B[3]_62 BIT_B[3]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_A_0
+  DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6
+  DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12
+  DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18
+  DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24
+  DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30
+  DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36
+  DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42
+  DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48
+  DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54
+  DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60
+  DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2
+  DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8
+  DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14
+  DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20
+  DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26
+  DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32
+  DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38
+  DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44
+  DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50
+  DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56
+  DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62
+  DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5
+  GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13
+  GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21
+  GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29
+  GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37
+  GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45
+  GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53
+  GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61
+  GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6
+  GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14
+  GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22
+  GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30
+  GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38
+  GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46
+  GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54
+  GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62
+  GDL_B_63 LOG0_DBL_A LOG0_DBL_B NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2
+  NBIT_A[0]_3 NBIT_A[0]_4 NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8
+  NBIT_A[0]_9 NBIT_A[0]_10 NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13
+  NBIT_A[0]_14 NBIT_A[0]_15 NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18
+  NBIT_A[0]_19 NBIT_A[0]_20 NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23
+  NBIT_A[0]_24 NBIT_A[0]_25 NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28
+  NBIT_A[0]_29 NBIT_A[0]_30 NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33
+  NBIT_A[0]_34 NBIT_A[0]_35 NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38
+  NBIT_A[0]_39 NBIT_A[0]_40 NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43
+  NBIT_A[0]_44 NBIT_A[0]_45 NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48
+  NBIT_A[0]_49 NBIT_A[0]_50 NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53
+  NBIT_A[0]_54 NBIT_A[0]_55 NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58
+  NBIT_A[0]_59 NBIT_A[0]_60 NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63
+  NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2 NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5
+  NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8 NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11
+  NBIT_A[1]_12 NBIT_A[1]_13 NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16
+  NBIT_A[1]_17 NBIT_A[1]_18 NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21
+  NBIT_A[1]_22 NBIT_A[1]_23 NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26
+  NBIT_A[1]_27 NBIT_A[1]_28 NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31
+  NBIT_A[1]_32 NBIT_A[1]_33 NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36
+  NBIT_A[1]_37 NBIT_A[1]_38 NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41
+  NBIT_A[1]_42 NBIT_A[1]_43 NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46
+  NBIT_A[1]_47 NBIT_A[1]_48 NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51
+  NBIT_A[1]_52 NBIT_A[1]_53 NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56
+  NBIT_A[1]_57 NBIT_A[1]_58 NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61
+  NBIT_A[1]_62 NBIT_A[1]_63 NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3
+  NBIT_A[2]_4 NBIT_A[2]_5 NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9
+  NBIT_A[2]_10 NBIT_A[2]_11 NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14
+  NBIT_A[2]_15 NBIT_A[2]_16 NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19
+  NBIT_A[2]_20 NBIT_A[2]_21 NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24
+  NBIT_A[2]_25 NBIT_A[2]_26 NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29
+  NBIT_A[2]_30 NBIT_A[2]_31 NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34
+  NBIT_A[2]_35 NBIT_A[2]_36 NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39
+  NBIT_A[2]_40 NBIT_A[2]_41 NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44
+  NBIT_A[2]_45 NBIT_A[2]_46 NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49
+  NBIT_A[2]_50 NBIT_A[2]_51 NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54
+  NBIT_A[2]_55 NBIT_A[2]_56 NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59
+  NBIT_A[2]_60 NBIT_A[2]_61 NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1
+  NBIT_A[3]_2 NBIT_A[3]_3 NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7
+  NBIT_A[3]_8 NBIT_A[3]_9 NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13
+  NBIT_A[3]_14 NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18
+  NBIT_A[3]_19 NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23
+  NBIT_A[3]_24 NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28
+  NBIT_A[3]_29 NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33
+  NBIT_A[3]_34 NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38
+  NBIT_A[3]_39 NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43
+  NBIT_A[3]_44 NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48
+  NBIT_A[3]_49 NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53
+  NBIT_A[3]_54 NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58
+  NBIT_A[3]_59 NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63
+  NBIT_B[0]_0 NBIT_B[0]_1 NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5
+  NBIT_B[0]_6 NBIT_B[0]_7 NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11
+  NBIT_B[0]_12 NBIT_B[0]_13 NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16
+  NBIT_B[0]_17 NBIT_B[0]_18 NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21
+  NBIT_B[0]_22 NBIT_B[0]_23 NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26
+  NBIT_B[0]_27 NBIT_B[0]_28 NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31
+  NBIT_B[0]_32 NBIT_B[0]_33 NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36
+  NBIT_B[0]_37 NBIT_B[0]_38 NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41
+  NBIT_B[0]_42 NBIT_B[0]_43 NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46
+  NBIT_B[0]_47 NBIT_B[0]_48 NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51
+  NBIT_B[0]_52 NBIT_B[0]_53 NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56
+  NBIT_B[0]_57 NBIT_B[0]_58 NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61
+  NBIT_B[0]_62 NBIT_B[0]_63 NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3
+  NBIT_B[1]_4 NBIT_B[1]_5 NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9
+  NBIT_B[1]_10 NBIT_B[1]_11 NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14
+  NBIT_B[1]_15 NBIT_B[1]_16 NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19
+  NBIT_B[1]_20 NBIT_B[1]_21 NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24
+  NBIT_B[1]_25 NBIT_B[1]_26 NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29
+  NBIT_B[1]_30 NBIT_B[1]_31 NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34
+  NBIT_B[1]_35 NBIT_B[1]_36 NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39
+  NBIT_B[1]_40 NBIT_B[1]_41 NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44
+  NBIT_B[1]_45 NBIT_B[1]_46 NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49
+  NBIT_B[1]_50 NBIT_B[1]_51 NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54
+  NBIT_B[1]_55 NBIT_B[1]_56 NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59
+  NBIT_B[1]_60 NBIT_B[1]_61 NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1
+  NBIT_B[2]_2 NBIT_B[2]_3 NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7
+  NBIT_B[2]_8 NBIT_B[2]_9 NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13
+  NBIT_B[2]_14 NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18
+  NBIT_B[2]_19 NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23
+  NBIT_B[2]_24 NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28
+  NBIT_B[2]_29 NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33
+  NBIT_B[2]_34 NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38
+  NBIT_B[2]_39 NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43
+  NBIT_B[2]_44 NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48
+  NBIT_B[2]_49 NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53
+  NBIT_B[2]_54 NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58
+  NBIT_B[2]_59 NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63
+  NBIT_B[3]_0 NBIT_B[3]_1 NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5
+  NBIT_B[3]_6 NBIT_B[3]_7 NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11
+  NBIT_B[3]_12 NBIT_B[3]_13 NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16
+  NBIT_B[3]_17 NBIT_B[3]_18 NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21
+  NBIT_B[3]_22 NBIT_B[3]_23 NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26
+  NBIT_B[3]_27 NBIT_B[3]_28 NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31
+  NBIT_B[3]_32 NBIT_B[3]_33 NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36
+  NBIT_B[3]_37 NBIT_B[3]_38 NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41
+  NBIT_B[3]_42 NBIT_B[3]_43 NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46
+  NBIT_B[3]_47 NBIT_B[3]_48 NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51
+  NBIT_B[3]_52 NBIT_B[3]_53 NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56
+  NBIT_B[3]_57 NBIT_B[3]_58 NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61
+  NBIT_B[3]_62 NBIT_B[3]_63 NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B
+  NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3
+  NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9
+  NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15
+  NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21
+  NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27
+  NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33
+  NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39
+  NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45
+  NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51
+  NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57
+  NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63
+  NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5
+  NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11
+  NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17
+  NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23
+  NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29
+  NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35
+  NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41
+  NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47
+  NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53
+  NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59
+  NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A NWL_CLK_B
+  NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42
+  VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50
+  VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58
+  VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VDDPE_64 VNWC VNWP_0 VNWP_1
+  VNWP_2 VNWP_3 VPW VSSE_0 VSSE_1 VSSE_2 VSSE_3 WE_A WE_B WRA_MA WRB_MA WTE_A
+  WTE_B
** SRAMdpw64d256CCICD32320: 3080 flat devices **
XFCWDEDGE ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A
+  NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A
+  NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VNWC VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE_32
+  VNWC VDDPE_32 VPW VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
+  SRAMdpw64d256FCWDEDGE
XINNERSUBCHANNEL BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34 BIT_A[0]_35 BIT_A[0]_36
+  BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40 BIT_A[0]_41 BIT_A[0]_42
+  BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46 BIT_A[0]_47 BIT_A[0]_48
+  BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52 BIT_A[0]_53 BIT_A[0]_54
+  BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58 BIT_A[0]_59 BIT_A[0]_60
+  BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34
+  BIT_A[1]_35 BIT_A[1]_36 BIT_A[1]_37 BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40
+  BIT_A[1]_41 BIT_A[1]_42 BIT_A[1]_43 BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46
+  BIT_A[1]_47 BIT_A[1]_48 BIT_A[1]_49 BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52
+  BIT_A[1]_53 BIT_A[1]_54 BIT_A[1]_55 BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58
+  BIT_A[1]_59 BIT_A[1]_60 BIT_A[1]_61 BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_32
+  BIT_A[2]_33 BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38
+  BIT_A[2]_39 BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44
+  BIT_A[2]_45 BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50
+  BIT_A[2]_51 BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56
+  BIT_A[2]_57 BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62
+  BIT_A[2]_63 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34 BIT_A[3]_35 BIT_A[3]_36
+  BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40 BIT_A[3]_41 BIT_A[3]_42
+  BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46 BIT_A[3]_47 BIT_A[3]_48
+  BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52 BIT_A[3]_53 BIT_A[3]_54
+  BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58 BIT_A[3]_59 BIT_A[3]_60
+  BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34
+  BIT_B[0]_35 BIT_B[0]_36 BIT_B[0]_37 BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40
+  BIT_B[0]_41 BIT_B[0]_42 BIT_B[0]_43 BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46
+  BIT_B[0]_47 BIT_B[0]_48 BIT_B[0]_49 BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52
+  BIT_B[0]_53 BIT_B[0]_54 BIT_B[0]_55 BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58
+  BIT_B[0]_59 BIT_B[0]_60 BIT_B[0]_61 BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_32
+  BIT_B[1]_33 BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38
+  BIT_B[1]_39 BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44
+  BIT_B[1]_45 BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50
+  BIT_B[1]_51 BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56
+  BIT_B[1]_57 BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62
+  BIT_B[1]_63 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34 BIT_B[2]_35 BIT_B[2]_36
+  BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40 BIT_B[2]_41 BIT_B[2]_42
+  BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46 BIT_B[2]_47 BIT_B[2]_48
+  BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52 BIT_B[2]_53 BIT_B[2]_54
+  BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58 BIT_B[2]_59 BIT_B[2]_60
+  BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34
+  BIT_B[3]_35 BIT_B[3]_36 BIT_B[3]_37 BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40
+  BIT_B[3]_41 BIT_B[3]_42 BIT_B[3]_43 BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46
+  BIT_B[3]_47 BIT_B[3]_48 BIT_B[3]_49 BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52
+  BIT_B[3]_53 BIT_B[3]_54 BIT_B[3]_55 BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58
+  BIT_B[3]_59 BIT_B[3]_60 BIT_B[3]_61 BIT_B[3]_62 BIT_B[3]_63 DATAIN_A_32
+  DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38
+  DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44
+  DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50
+  DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56
+  DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62
+  DATAIN_A_63 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36
+  DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42
+  DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48
+  DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54
+  DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60
+  DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35
+  GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43
+  GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51
+  GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59
+  GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35
+  GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43
+  GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51
+  GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59
+  GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 NBIT_A[0]_32 NBIT_A[0]_33 NBIT_A[0]_34
+  NBIT_A[0]_35 NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38 NBIT_A[0]_39
+  NBIT_A[0]_40 NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43 NBIT_A[0]_44
+  NBIT_A[0]_45 NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48 NBIT_A[0]_49
+  NBIT_A[0]_50 NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53 NBIT_A[0]_54
+  NBIT_A[0]_55 NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58 NBIT_A[0]_59
+  NBIT_A[0]_60 NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63 NBIT_A[1]_32
+  NBIT_A[1]_33 NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36 NBIT_A[1]_37
+  NBIT_A[1]_38 NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41 NBIT_A[1]_42
+  NBIT_A[1]_43 NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46 NBIT_A[1]_47
+  NBIT_A[1]_48 NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51 NBIT_A[1]_52
+  NBIT_A[1]_53 NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56 NBIT_A[1]_57
+  NBIT_A[1]_58 NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61 NBIT_A[1]_62
+  NBIT_A[1]_63 NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34 NBIT_A[2]_35
+  NBIT_A[2]_36 NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39 NBIT_A[2]_40
+  NBIT_A[2]_41 NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44 NBIT_A[2]_45
+  NBIT_A[2]_46 NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49 NBIT_A[2]_50
+  NBIT_A[2]_51 NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54 NBIT_A[2]_55
+  NBIT_A[2]_56 NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59 NBIT_A[2]_60
+  NBIT_A[2]_61 NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_32 NBIT_A[3]_33
+  NBIT_A[3]_34 NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38
+  NBIT_A[3]_39 NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43
+  NBIT_A[3]_44 NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48
+  NBIT_A[3]_49 NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53
+  NBIT_A[3]_54 NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58
+  NBIT_A[3]_59 NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63
+  NBIT_B[0]_32 NBIT_B[0]_33 NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36
+  NBIT_B[0]_37 NBIT_B[0]_38 NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41
+  NBIT_B[0]_42 NBIT_B[0]_43 NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46
+  NBIT_B[0]_47 NBIT_B[0]_48 NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51
+  NBIT_B[0]_52 NBIT_B[0]_53 NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56
+  NBIT_B[0]_57 NBIT_B[0]_58 NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61
+  NBIT_B[0]_62 NBIT_B[0]_63 NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34
+  NBIT_B[1]_35 NBIT_B[1]_36 NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39
+  NBIT_B[1]_40 NBIT_B[1]_41 NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44
+  NBIT_B[1]_45 NBIT_B[1]_46 NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49
+  NBIT_B[1]_50 NBIT_B[1]_51 NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54
+  NBIT_B[1]_55 NBIT_B[1]_56 NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59
+  NBIT_B[1]_60 NBIT_B[1]_61 NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_32
+  NBIT_B[2]_33 NBIT_B[2]_34 NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37
+  NBIT_B[2]_38 NBIT_B[2]_39 NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42
+  NBIT_B[2]_43 NBIT_B[2]_44 NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47
+  NBIT_B[2]_48 NBIT_B[2]_49 NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52
+  NBIT_B[2]_53 NBIT_B[2]_54 NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57
+  NBIT_B[2]_58 NBIT_B[2]_59 NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62
+  NBIT_B[2]_63 NBIT_B[3]_32 NBIT_B[3]_33 NBIT_B[3]_34 NBIT_B[3]_35
+  NBIT_B[3]_36 NBIT_B[3]_37 NBIT_B[3]_38 NBIT_B[3]_39 NBIT_B[3]_40
+  NBIT_B[3]_41 NBIT_B[3]_42 NBIT_B[3]_43 NBIT_B[3]_44 NBIT_B[3]_45
+  NBIT_B[3]_46 NBIT_B[3]_47 NBIT_B[3]_48 NBIT_B[3]_49 NBIT_B[3]_50
+  NBIT_B[3]_51 NBIT_B[3]_52 NBIT_B[3]_53 NBIT_B[3]_54 NBIT_B[3]_55
+  NBIT_B[3]_56 NBIT_B[3]_57 NBIT_B[3]_58 NBIT_B[3]_59 NBIT_B[3]_60
+  NBIT_B[3]_61 NBIT_B[3]_62 NBIT_B[3]_63 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34
+  NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40
+  NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46
+  NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52
+  NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58
+  NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_32
+  NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38
+  NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44
+  NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50
+  NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56
+  NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62
+  NWGSEL_B_63 VNWC VDDPE_33 VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38
+  VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46
+  VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54
+  VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62
+  VDDPE_63 VDDPE_64 VPW SRAMdpw64d256CCICD032O
XOUTERSUBCHANNEL BIT_A[0]_31 BIT_A[0]_30 BIT_A[0]_29 BIT_A[0]_28 BIT_A[0]_27
+  BIT_A[0]_26 BIT_A[0]_25 BIT_A[0]_24 BIT_A[0]_23 BIT_A[0]_22 BIT_A[0]_21
+  BIT_A[0]_20 BIT_A[0]_19 BIT_A[0]_18 BIT_A[0]_17 BIT_A[0]_16 BIT_A[0]_15
+  BIT_A[0]_14 BIT_A[0]_13 BIT_A[0]_12 BIT_A[0]_11 BIT_A[0]_10 BIT_A[0]_9
+  BIT_A[0]_8 BIT_A[0]_7 BIT_A[0]_6 BIT_A[0]_5 BIT_A[0]_4 BIT_A[0]_3
+  BIT_A[0]_2 BIT_A[0]_1 BIT_A[0]_0 BIT_A[1]_31 BIT_A[1]_30 BIT_A[1]_29
+  BIT_A[1]_28 BIT_A[1]_27 BIT_A[1]_26 BIT_A[1]_25 BIT_A[1]_24 BIT_A[1]_23
+  BIT_A[1]_22 BIT_A[1]_21 BIT_A[1]_20 BIT_A[1]_19 BIT_A[1]_18 BIT_A[1]_17
+  BIT_A[1]_16 BIT_A[1]_15 BIT_A[1]_14 BIT_A[1]_13 BIT_A[1]_12 BIT_A[1]_11
+  BIT_A[1]_10 BIT_A[1]_9 BIT_A[1]_8 BIT_A[1]_7 BIT_A[1]_6 BIT_A[1]_5
+  BIT_A[1]_4 BIT_A[1]_3 BIT_A[1]_2 BIT_A[1]_1 BIT_A[1]_0 BIT_A[2]_31
+  BIT_A[2]_30 BIT_A[2]_29 BIT_A[2]_28 BIT_A[2]_27 BIT_A[2]_26 BIT_A[2]_25
+  BIT_A[2]_24 BIT_A[2]_23 BIT_A[2]_22 BIT_A[2]_21 BIT_A[2]_20 BIT_A[2]_19
+  BIT_A[2]_18 BIT_A[2]_17 BIT_A[2]_16 BIT_A[2]_15 BIT_A[2]_14 BIT_A[2]_13
+  BIT_A[2]_12 BIT_A[2]_11 BIT_A[2]_10 BIT_A[2]_9 BIT_A[2]_8 BIT_A[2]_7
+  BIT_A[2]_6 BIT_A[2]_5 BIT_A[2]_4 BIT_A[2]_3 BIT_A[2]_2 BIT_A[2]_1
+  BIT_A[2]_0 BIT_A[3]_31 BIT_A[3]_30 BIT_A[3]_29 BIT_A[3]_28 BIT_A[3]_27
+  BIT_A[3]_26 BIT_A[3]_25 BIT_A[3]_24 BIT_A[3]_23 BIT_A[3]_22 BIT_A[3]_21
+  BIT_A[3]_20 BIT_A[3]_19 BIT_A[3]_18 BIT_A[3]_17 BIT_A[3]_16 BIT_A[3]_15
+  BIT_A[3]_14 BIT_A[3]_13 BIT_A[3]_12 BIT_A[3]_11 BIT_A[3]_10 BIT_A[3]_9
+  BIT_A[3]_8 BIT_A[3]_7 BIT_A[3]_6 BIT_A[3]_5 BIT_A[3]_4 BIT_A[3]_3
+  BIT_A[3]_2 BIT_A[3]_1 BIT_A[3]_0 BIT_B[0]_31 BIT_B[0]_30 BIT_B[0]_29
+  BIT_B[0]_28 BIT_B[0]_27 BIT_B[0]_26 BIT_B[0]_25 BIT_B[0]_24 BIT_B[0]_23
+  BIT_B[0]_22 BIT_B[0]_21 BIT_B[0]_20 BIT_B[0]_19 BIT_B[0]_18 BIT_B[0]_17
+  BIT_B[0]_16 BIT_B[0]_15 BIT_B[0]_14 BIT_B[0]_13 BIT_B[0]_12 BIT_B[0]_11
+  BIT_B[0]_10 BIT_B[0]_9 BIT_B[0]_8 BIT_B[0]_7 BIT_B[0]_6 BIT_B[0]_5
+  BIT_B[0]_4 BIT_B[0]_3 BIT_B[0]_2 BIT_B[0]_1 BIT_B[0]_0 BIT_B[1]_31
+  BIT_B[1]_30 BIT_B[1]_29 BIT_B[1]_28 BIT_B[1]_27 BIT_B[1]_26 BIT_B[1]_25
+  BIT_B[1]_24 BIT_B[1]_23 BIT_B[1]_22 BIT_B[1]_21 BIT_B[1]_20 BIT_B[1]_19
+  BIT_B[1]_18 BIT_B[1]_17 BIT_B[1]_16 BIT_B[1]_15 BIT_B[1]_14 BIT_B[1]_13
+  BIT_B[1]_12 BIT_B[1]_11 BIT_B[1]_10 BIT_B[1]_9 BIT_B[1]_8 BIT_B[1]_7
+  BIT_B[1]_6 BIT_B[1]_5 BIT_B[1]_4 BIT_B[1]_3 BIT_B[1]_2 BIT_B[1]_1
+  BIT_B[1]_0 BIT_B[2]_31 BIT_B[2]_30 BIT_B[2]_29 BIT_B[2]_28 BIT_B[2]_27
+  BIT_B[2]_26 BIT_B[2]_25 BIT_B[2]_24 BIT_B[2]_23 BIT_B[2]_22 BIT_B[2]_21
+  BIT_B[2]_20 BIT_B[2]_19 BIT_B[2]_18 BIT_B[2]_17 BIT_B[2]_16 BIT_B[2]_15
+  BIT_B[2]_14 BIT_B[2]_13 BIT_B[2]_12 BIT_B[2]_11 BIT_B[2]_10 BIT_B[2]_9
+  BIT_B[2]_8 BIT_B[2]_7 BIT_B[2]_6 BIT_B[2]_5 BIT_B[2]_4 BIT_B[2]_3
+  BIT_B[2]_2 BIT_B[2]_1 BIT_B[2]_0 BIT_B[3]_31 BIT_B[3]_30 BIT_B[3]_29
+  BIT_B[3]_28 BIT_B[3]_27 BIT_B[3]_26 BIT_B[3]_25 BIT_B[3]_24 BIT_B[3]_23
+  BIT_B[3]_22 BIT_B[3]_21 BIT_B[3]_20 BIT_B[3]_19 BIT_B[3]_18 BIT_B[3]_17
+  BIT_B[3]_16 BIT_B[3]_15 BIT_B[3]_14 BIT_B[3]_13 BIT_B[3]_12 BIT_B[3]_11
+  BIT_B[3]_10 BIT_B[3]_9 BIT_B[3]_8 BIT_B[3]_7 BIT_B[3]_6 BIT_B[3]_5
+  BIT_B[3]_4 BIT_B[3]_3 BIT_B[3]_2 BIT_B[3]_1 BIT_B[3]_0 DATAIN_A_31
+  DATAIN_A_30 DATAIN_A_29 DATAIN_A_28 DATAIN_A_27 DATAIN_A_26 DATAIN_A_25
+  DATAIN_A_24 DATAIN_A_23 DATAIN_A_22 DATAIN_A_21 DATAIN_A_20 DATAIN_A_19
+  DATAIN_A_18 DATAIN_A_17 DATAIN_A_16 DATAIN_A_15 DATAIN_A_14 DATAIN_A_13
+  DATAIN_A_12 DATAIN_A_11 DATAIN_A_10 DATAIN_A_9 DATAIN_A_8 DATAIN_A_7
+  DATAIN_A_6 DATAIN_A_5 DATAIN_A_4 DATAIN_A_3 DATAIN_A_2 DATAIN_A_1
+  DATAIN_A_0 DATAIN_B_31 DATAIN_B_30 DATAIN_B_29 DATAIN_B_28 DATAIN_B_27
+  DATAIN_B_26 DATAIN_B_25 DATAIN_B_24 DATAIN_B_23 DATAIN_B_22 DATAIN_B_21
+  DATAIN_B_20 DATAIN_B_19 DATAIN_B_18 DATAIN_B_17 DATAIN_B_16 DATAIN_B_15
+  DATAIN_B_14 DATAIN_B_13 DATAIN_B_12 DATAIN_B_11 DATAIN_B_10 DATAIN_B_9
+  DATAIN_B_8 DATAIN_B_7 DATAIN_B_6 DATAIN_B_5 DATAIN_B_4 DATAIN_B_3
+  DATAIN_B_2 DATAIN_B_1 DATAIN_B_0 GDL_A_31 GDL_A_30 GDL_A_29 GDL_A_28
+  GDL_A_27 GDL_A_26 GDL_A_25 GDL_A_24 GDL_A_23 GDL_A_22 GDL_A_21 GDL_A_20
+  GDL_A_19 GDL_A_18 GDL_A_17 GDL_A_16 GDL_A_15 GDL_A_14 GDL_A_13 GDL_A_12
+  GDL_A_11 GDL_A_10 GDL_A_9 GDL_A_8 GDL_A_7 GDL_A_6 GDL_A_5 GDL_A_4 GDL_A_3
+  GDL_A_2 GDL_A_1 GDL_A_0 GDL_B_31 GDL_B_30 GDL_B_29 GDL_B_28 GDL_B_27
+  GDL_B_26 GDL_B_25 GDL_B_24 GDL_B_23 GDL_B_22 GDL_B_21 GDL_B_20 GDL_B_19
+  GDL_B_18 GDL_B_17 GDL_B_16 GDL_B_15 GDL_B_14 GDL_B_13 GDL_B_12 GDL_B_11
+  GDL_B_10 GDL_B_9 GDL_B_8 GDL_B_7 GDL_B_6 GDL_B_5 GDL_B_4 GDL_B_3 GDL_B_2
+  GDL_B_1 GDL_B_0 NBIT_A[0]_31 NBIT_A[0]_30 NBIT_A[0]_29 NBIT_A[0]_28
+  NBIT_A[0]_27 NBIT_A[0]_26 NBIT_A[0]_25 NBIT_A[0]_24 NBIT_A[0]_23
+  NBIT_A[0]_22 NBIT_A[0]_21 NBIT_A[0]_20 NBIT_A[0]_19 NBIT_A[0]_18
+  NBIT_A[0]_17 NBIT_A[0]_16 NBIT_A[0]_15 NBIT_A[0]_14 NBIT_A[0]_13
+  NBIT_A[0]_12 NBIT_A[0]_11 NBIT_A[0]_10 NBIT_A[0]_9 NBIT_A[0]_8 NBIT_A[0]_7
+  NBIT_A[0]_6 NBIT_A[0]_5 NBIT_A[0]_4 NBIT_A[0]_3 NBIT_A[0]_2 NBIT_A[0]_1
+  NBIT_A[0]_0 NBIT_A[1]_31 NBIT_A[1]_30 NBIT_A[1]_29 NBIT_A[1]_28
+  NBIT_A[1]_27 NBIT_A[1]_26 NBIT_A[1]_25 NBIT_A[1]_24 NBIT_A[1]_23
+  NBIT_A[1]_22 NBIT_A[1]_21 NBIT_A[1]_20 NBIT_A[1]_19 NBIT_A[1]_18
+  NBIT_A[1]_17 NBIT_A[1]_16 NBIT_A[1]_15 NBIT_A[1]_14 NBIT_A[1]_13
+  NBIT_A[1]_12 NBIT_A[1]_11 NBIT_A[1]_10 NBIT_A[1]_9 NBIT_A[1]_8 NBIT_A[1]_7
+  NBIT_A[1]_6 NBIT_A[1]_5 NBIT_A[1]_4 NBIT_A[1]_3 NBIT_A[1]_2 NBIT_A[1]_1
+  NBIT_A[1]_0 NBIT_A[2]_31 NBIT_A[2]_30 NBIT_A[2]_29 NBIT_A[2]_28
+  NBIT_A[2]_27 NBIT_A[2]_26 NBIT_A[2]_25 NBIT_A[2]_24 NBIT_A[2]_23
+  NBIT_A[2]_22 NBIT_A[2]_21 NBIT_A[2]_20 NBIT_A[2]_19 NBIT_A[2]_18
+  NBIT_A[2]_17 NBIT_A[2]_16 NBIT_A[2]_15 NBIT_A[2]_14 NBIT_A[2]_13
+  NBIT_A[2]_12 NBIT_A[2]_11 NBIT_A[2]_10 NBIT_A[2]_9 NBIT_A[2]_8 NBIT_A[2]_7
+  NBIT_A[2]_6 NBIT_A[2]_5 NBIT_A[2]_4 NBIT_A[2]_3 NBIT_A[2]_2 NBIT_A[2]_1
+  NBIT_A[2]_0 NBIT_A[3]_31 NBIT_A[3]_30 NBIT_A[3]_29 NBIT_A[3]_28
+  NBIT_A[3]_27 NBIT_A[3]_26 NBIT_A[3]_25 NBIT_A[3]_24 NBIT_A[3]_23
+  NBIT_A[3]_22 NBIT_A[3]_21 NBIT_A[3]_20 NBIT_A[3]_19 NBIT_A[3]_18
+  NBIT_A[3]_17 NBIT_A[3]_16 NBIT_A[3]_15 NBIT_A[3]_14 NBIT_A[3]_13
+  NBIT_A[3]_12 NBIT_A[3]_11 NBIT_A[3]_10 NBIT_A[3]_9 NBIT_A[3]_8 NBIT_A[3]_7
+  NBIT_A[3]_6 NBIT_A[3]_5 NBIT_A[3]_4 NBIT_A[3]_3 NBIT_A[3]_2 NBIT_A[3]_1
+  NBIT_A[3]_0 NBIT_B[0]_31 NBIT_B[0]_30 NBIT_B[0]_29 NBIT_B[0]_28
+  NBIT_B[0]_27 NBIT_B[0]_26 NBIT_B[0]_25 NBIT_B[0]_24 NBIT_B[0]_23
+  NBIT_B[0]_22 NBIT_B[0]_21 NBIT_B[0]_20 NBIT_B[0]_19 NBIT_B[0]_18
+  NBIT_B[0]_17 NBIT_B[0]_16 NBIT_B[0]_15 NBIT_B[0]_14 NBIT_B[0]_13
+  NBIT_B[0]_12 NBIT_B[0]_11 NBIT_B[0]_10 NBIT_B[0]_9 NBIT_B[0]_8 NBIT_B[0]_7
+  NBIT_B[0]_6 NBIT_B[0]_5 NBIT_B[0]_4 NBIT_B[0]_3 NBIT_B[0]_2 NBIT_B[0]_1
+  NBIT_B[0]_0 NBIT_B[1]_31 NBIT_B[1]_30 NBIT_B[1]_29 NBIT_B[1]_28
+  NBIT_B[1]_27 NBIT_B[1]_26 NBIT_B[1]_25 NBIT_B[1]_24 NBIT_B[1]_23
+  NBIT_B[1]_22 NBIT_B[1]_21 NBIT_B[1]_20 NBIT_B[1]_19 NBIT_B[1]_18
+  NBIT_B[1]_17 NBIT_B[1]_16 NBIT_B[1]_15 NBIT_B[1]_14 NBIT_B[1]_13
+  NBIT_B[1]_12 NBIT_B[1]_11 NBIT_B[1]_10 NBIT_B[1]_9 NBIT_B[1]_8 NBIT_B[1]_7
+  NBIT_B[1]_6 NBIT_B[1]_5 NBIT_B[1]_4 NBIT_B[1]_3 NBIT_B[1]_2 NBIT_B[1]_1
+  NBIT_B[1]_0 NBIT_B[2]_31 NBIT_B[2]_30 NBIT_B[2]_29 NBIT_B[2]_28
+  NBIT_B[2]_27 NBIT_B[2]_26 NBIT_B[2]_25 NBIT_B[2]_24 NBIT_B[2]_23
+  NBIT_B[2]_22 NBIT_B[2]_21 NBIT_B[2]_20 NBIT_B[2]_19 NBIT_B[2]_18
+  NBIT_B[2]_17 NBIT_B[2]_16 NBIT_B[2]_15 NBIT_B[2]_14 NBIT_B[2]_13
+  NBIT_B[2]_12 NBIT_B[2]_11 NBIT_B[2]_10 NBIT_B[2]_9 NBIT_B[2]_8 NBIT_B[2]_7
+  NBIT_B[2]_6 NBIT_B[2]_5 NBIT_B[2]_4 NBIT_B[2]_3 NBIT_B[2]_2 NBIT_B[2]_1
+  NBIT_B[2]_0 NBIT_B[3]_31 NBIT_B[3]_30 NBIT_B[3]_29 NBIT_B[3]_28
+  NBIT_B[3]_27 NBIT_B[3]_26 NBIT_B[3]_25 NBIT_B[3]_24 NBIT_B[3]_23
+  NBIT_B[3]_22 NBIT_B[3]_21 NBIT_B[3]_20 NBIT_B[3]_19 NBIT_B[3]_18
+  NBIT_B[3]_17 NBIT_B[3]_16 NBIT_B[3]_15 NBIT_B[3]_14 NBIT_B[3]_13
+  NBIT_B[3]_12 NBIT_B[3]_11 NBIT_B[3]_10 NBIT_B[3]_9 NBIT_B[3]_8 NBIT_B[3]_7
+  NBIT_B[3]_6 NBIT_B[3]_5 NBIT_B[3]_4 NBIT_B[3]_3 NBIT_B[3]_2 NBIT_B[3]_1
+  NBIT_B[3]_0 NWGSEL_A_31 NWGSEL_A_30 NWGSEL_A_29 NWGSEL_A_28 NWGSEL_A_27
+  NWGSEL_A_26 NWGSEL_A_25 NWGSEL_A_24 NWGSEL_A_23 NWGSEL_A_22 NWGSEL_A_21
+  NWGSEL_A_20 NWGSEL_A_19 NWGSEL_A_18 NWGSEL_A_17 NWGSEL_A_16 NWGSEL_A_15
+  NWGSEL_A_14 NWGSEL_A_13 NWGSEL_A_12 NWGSEL_A_11 NWGSEL_A_10 NWGSEL_A_9
+  NWGSEL_A_8 NWGSEL_A_7 NWGSEL_A_6 NWGSEL_A_5 NWGSEL_A_4 NWGSEL_A_3
+  NWGSEL_A_2 NWGSEL_A_1 NWGSEL_A_0 NWGSEL_B_31 NWGSEL_B_30 NWGSEL_B_29
+  NWGSEL_B_28 NWGSEL_B_27 NWGSEL_B_26 NWGSEL_B_25 NWGSEL_B_24 NWGSEL_B_23
+  NWGSEL_B_22 NWGSEL_B_21 NWGSEL_B_20 NWGSEL_B_19 NWGSEL_B_18 NWGSEL_B_17
+  NWGSEL_B_16 NWGSEL_B_15 NWGSEL_B_14 NWGSEL_B_13 NWGSEL_B_12 NWGSEL_B_11
+  NWGSEL_B_10 NWGSEL_B_9 NWGSEL_B_8 NWGSEL_B_7 NWGSEL_B_6 NWGSEL_B_5
+  NWGSEL_B_4 NWGSEL_B_3 NWGSEL_B_2 NWGSEL_B_1 NWGSEL_B_0 VNWC VDDPE_31
+  VDDPE_30 VDDPE_29 VDDPE_28 VDDPE_27 VDDPE_26 VDDPE_25 VDDPE_24 VDDPE_23
+  VDDPE_22 VDDPE_21 VDDPE_20 VDDPE_19 VDDPE_18 VDDPE_17 VDDPE_16 VDDPE_15
+  VDDPE_14 VDDPE_13 VDDPE_12 VDDPE_11 VDDPE_10 VDDPE_9 VDDPE_8 VDDPE_7
+  VDDPE_6 VDDPE_5 VDDPE_4 VDDPE_3 VDDPE_2 VDDPE_1 VDDPE_0 VPW
+  SRAMdpw64d256CCICD032O
.ENDS SRAMdpw64d256CCICD32320
****
.SUBCKT SRAMdpw64d256CCO BIT_A BIT_B CORED DATAIN NBIT_A NBIT_B NCORED VDDC
+  VDDCE VDDPE VNWC VPW VSSE WL_A WL_B
** SRAMdpw64d256CCO: 8 flat devices **
X_MIcell.MXNpdl NCORED CORED VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MIcell.MXNpdr CORED NCORED VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MIcell.MXNpgl_0 NBIT_A WL_A NCORED VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MIcell.MXNpgl_1 NBIT_B WL_B NCORED VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MIcell.MXNpgr_0 BIT_A WL_A CORED VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MIcell.MXNpgr_1 BIT_B WL_B CORED VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MIcell.MXPpul NCORED CORED VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MIcell.MXPpur CORED NCORED VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS SRAMdpw64d256CCO
****
.SUBCKT SRAMdpw64d256WRAPPED_CCO BIT_A BIT_B DATAIN NBIT_A NBIT_B VDDC VDDCE
+  VDDPE VNWC VPW VSSE WL_A WL_B
** SRAMdpw64d256WRAPPED_CCO: 8 flat devices **
XI0 BIT_A BIT_B CORED DATAIN NBIT_A NBIT_B NCORED VDDC VDDCE VDDPE VNWC VPW
+  VSSE WL_A WL_B SRAMdpw64d256CCO
.ENDS SRAMdpw64d256WRAPPED_CCO
****
.SUBCKT SRAMdpw64d256CCI BIT_A BIT_B CORED GDL NBIT_A NBIT_B NCORED NWGSEL
+  VDDC VDDCE VDDPE VNWC VPW VSSE WL_A WL_B
** SRAMdpw64d256CCI: 8 flat devices **
X_MIcell.MXNpdl NCORED CORED VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MIcell.MXNpdr CORED NCORED VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MIcell.MXNpgl_0 NBIT_A WL_A NCORED VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MIcell.MXNpgl_1 NBIT_B WL_B NCORED VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MIcell.MXNpgr_0 BIT_A WL_A CORED VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MIcell.MXNpgr_1 BIT_B WL_B CORED VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MIcell.MXPpul NCORED CORED VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MIcell.MXPpur CORED NCORED VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS SRAMdpw64d256CCI
****
.SUBCKT SRAMdpw64d256WRAPPED_CCI BIT_A BIT_B GDL NBIT_A NBIT_B NWGSEL VDDC
+  VDDCE VDDPE VNWC VPW VSSE WL_A WL_B
** SRAMdpw64d256WRAPPED_CCI: 8 flat devices **
XI0 BIT_A BIT_B CORED GDL NBIT_A NBIT_B NCORED NWGSEL VDDC VDDCE VDDPE VNWC
+  VPW VSSE WL_A WL_B SRAMdpw64d256CCI
.ENDS SRAMdpw64d256WRAPPED_CCI
****
.SUBCKT SRAMdpw64d256CCARR4X4 BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1
+  BIT_B_2 BIT_B_3 DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2
+  NBIT_A_3 NBIT_B_0 NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0
+  VDDCE_1 VDDCE_2 VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2
+  VDDPE_3 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_0
+  WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3
** SRAMdpw64d256CCARR4X4: 128 flat devices **
XICELL0_0 BIT_A_0 BIT_B_0 DATAIN_0 NBIT_A_0 NBIT_B_0 VDDC_0 VDDCE_0 VDDPE_0
+  VNWC_0 VPW_0 VSSE WL_A_0 WL_B_0 SRAMdpw64d256WRAPPED_CCO
XICELL0_1 BIT_A_1 BIT_B_1 GDL_0 NBIT_A_1 NBIT_B_1 NWGSEL_0 VDDC_1 VDDCE_1
+  VDDPE_1 VNWC_1 VPW_1 VSSE WL_A_0 WL_B_0 SRAMdpw64d256WRAPPED_CCI
XICELL0_2 BIT_A_2 BIT_B_2 GDL_1 NBIT_A_2 NBIT_B_2 NWGSEL_1 VDDC_2 VDDCE_2
+  VDDPE_2 VNWC_2 VPW_2 VSSE WL_A_0 WL_B_0 SRAMdpw64d256WRAPPED_CCI
XICELL0_3 BIT_A_3 BIT_B_3 DATAIN_1 NBIT_A_3 NBIT_B_3 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_3 VPW_3 VSSE WL_A_0 WL_B_0 SRAMdpw64d256WRAPPED_CCO
XICELL1_0 BIT_A_0 BIT_B_0 DATAIN_0 NBIT_A_0 NBIT_B_0 VDDC_0 VDDCE_0 VDDPE_0
+  VNWC_0 VPW_0 VSSE WL_A_1 WL_B_1 SRAMdpw64d256WRAPPED_CCO
XICELL1_1 BIT_A_1 BIT_B_1 GDL_0 NBIT_A_1 NBIT_B_1 NWGSEL_0 VDDC_1 VDDCE_1
+  VDDPE_1 VNWC_1 VPW_1 VSSE WL_A_1 WL_B_1 SRAMdpw64d256WRAPPED_CCI
XICELL1_2 BIT_A_2 BIT_B_2 GDL_1 NBIT_A_2 NBIT_B_2 NWGSEL_1 VDDC_2 VDDCE_2
+  VDDPE_2 VNWC_2 VPW_2 VSSE WL_A_1 WL_B_1 SRAMdpw64d256WRAPPED_CCI
XICELL1_3 BIT_A_3 BIT_B_3 DATAIN_1 NBIT_A_3 NBIT_B_3 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_3 VPW_3 VSSE WL_A_1 WL_B_1 SRAMdpw64d256WRAPPED_CCO
XICELL2_0 BIT_A_0 BIT_B_0 DATAIN_0 NBIT_A_0 NBIT_B_0 VDDC_0 VDDCE_0 VDDPE_0
+  VNWC_0 VPW_0 VSSE WL_A_2 WL_B_2 SRAMdpw64d256WRAPPED_CCO
XICELL2_1 BIT_A_1 BIT_B_1 GDL_0 NBIT_A_1 NBIT_B_1 NWGSEL_0 VDDC_1 VDDCE_1
+  VDDPE_1 VNWC_1 VPW_1 VSSE WL_A_2 WL_B_2 SRAMdpw64d256WRAPPED_CCI
XICELL2_2 BIT_A_2 BIT_B_2 GDL_1 NBIT_A_2 NBIT_B_2 NWGSEL_1 VDDC_2 VDDCE_2
+  VDDPE_2 VNWC_2 VPW_2 VSSE WL_A_2 WL_B_2 SRAMdpw64d256WRAPPED_CCI
XICELL2_3 BIT_A_3 BIT_B_3 DATAIN_1 NBIT_A_3 NBIT_B_3 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_3 VPW_3 VSSE WL_A_2 WL_B_2 SRAMdpw64d256WRAPPED_CCO
XICELL3_0 BIT_A_0 BIT_B_0 DATAIN_0 NBIT_A_0 NBIT_B_0 VDDC_0 VDDCE_0 VDDPE_0
+  VNWC_0 VPW_0 VSSE WL_A_3 WL_B_3 SRAMdpw64d256WRAPPED_CCO
XICELL3_1 BIT_A_1 BIT_B_1 GDL_0 NBIT_A_1 NBIT_B_1 NWGSEL_0 VDDC_1 VDDCE_1
+  VDDPE_1 VNWC_1 VPW_1 VSSE WL_A_3 WL_B_3 SRAMdpw64d256WRAPPED_CCI
XICELL3_2 BIT_A_2 BIT_B_2 GDL_1 NBIT_A_2 NBIT_B_2 NWGSEL_1 VDDC_2 VDDCE_2
+  VDDPE_2 VNWC_2 VPW_2 VSSE WL_A_3 WL_B_3 SRAMdpw64d256WRAPPED_CCI
XICELL3_3 BIT_A_3 BIT_B_3 DATAIN_1 NBIT_A_3 NBIT_B_3 VDDC_3 VDDCE_3 VDDPE_3
+  VNWC_3 VPW_3 VSSE WL_A_3 WL_B_3 SRAMdpw64d256WRAPPED_CCO
.ENDS SRAMdpw64d256CCARR4X4
****
.SUBCKT SRAMdpw64d256CARRAY_64_32L BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_A_4
+  BIT_A_5 BIT_A_6 BIT_A_7 BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_A_12 BIT_A_13
+  BIT_A_14 BIT_A_15 BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_A_20 BIT_A_21
+  BIT_A_22 BIT_A_23 BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_A_28 BIT_A_29
+  BIT_A_30 BIT_A_31 BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_A_36 BIT_A_37
+  BIT_A_38 BIT_A_39 BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_A_44 BIT_A_45
+  BIT_A_46 BIT_A_47 BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_A_52 BIT_A_53
+  BIT_A_54 BIT_A_55 BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_A_60 BIT_A_61
+  BIT_A_62 BIT_A_63 BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_A_68 BIT_A_69
+  BIT_A_70 BIT_A_71 BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_A_76 BIT_A_77
+  BIT_A_78 BIT_A_79 BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_A_84 BIT_A_85
+  BIT_A_86 BIT_A_87 BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_A_92 BIT_A_93
+  BIT_A_94 BIT_A_95 BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_A_100 BIT_A_101
+  BIT_A_102 BIT_A_103 BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_A_108
+  BIT_A_109 BIT_A_110 BIT_A_111 BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115
+  BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_A_120 BIT_A_121 BIT_A_122
+  BIT_A_123 BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_0 BIT_B_1 BIT_B_2
+  BIT_B_3 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  BIT_B_12 BIT_B_13 BIT_B_14 BIT_B_15 BIT_B_16 BIT_B_17 BIT_B_18 BIT_B_19
+  BIT_B_20 BIT_B_21 BIT_B_22 BIT_B_23 BIT_B_24 BIT_B_25 BIT_B_26 BIT_B_27
+  BIT_B_28 BIT_B_29 BIT_B_30 BIT_B_31 BIT_B_32 BIT_B_33 BIT_B_34 BIT_B_35
+  BIT_B_36 BIT_B_37 BIT_B_38 BIT_B_39 BIT_B_40 BIT_B_41 BIT_B_42 BIT_B_43
+  BIT_B_44 BIT_B_45 BIT_B_46 BIT_B_47 BIT_B_48 BIT_B_49 BIT_B_50 BIT_B_51
+  BIT_B_52 BIT_B_53 BIT_B_54 BIT_B_55 BIT_B_56 BIT_B_57 BIT_B_58 BIT_B_59
+  BIT_B_60 BIT_B_61 BIT_B_62 BIT_B_63 BIT_B_64 BIT_B_65 BIT_B_66 BIT_B_67
+  BIT_B_68 BIT_B_69 BIT_B_70 BIT_B_71 BIT_B_72 BIT_B_73 BIT_B_74 BIT_B_75
+  BIT_B_76 BIT_B_77 BIT_B_78 BIT_B_79 BIT_B_80 BIT_B_81 BIT_B_82 BIT_B_83
+  BIT_B_84 BIT_B_85 BIT_B_86 BIT_B_87 BIT_B_88 BIT_B_89 BIT_B_90 BIT_B_91
+  BIT_B_92 BIT_B_93 BIT_B_94 BIT_B_95 BIT_B_96 BIT_B_97 BIT_B_98 BIT_B_99
+  BIT_B_100 BIT_B_101 BIT_B_102 BIT_B_103 BIT_B_104 BIT_B_105 BIT_B_106
+  BIT_B_107 BIT_B_108 BIT_B_109 BIT_B_110 BIT_B_111 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 BIT_B_116 BIT_B_117 BIT_B_118 BIT_B_119 BIT_B_120
+  BIT_B_121 BIT_B_122 BIT_B_123 BIT_B_124 BIT_B_125 BIT_B_126 BIT_B_127
+  DATAIN_0 DATAIN_1 DATAIN_2 DATAIN_3 DATAIN_4 DATAIN_5 DATAIN_6 DATAIN_7
+  DATAIN_8 DATAIN_9 DATAIN_10 DATAIN_11 DATAIN_12 DATAIN_13 DATAIN_14
+  DATAIN_15 DATAIN_16 DATAIN_17 DATAIN_18 DATAIN_19 DATAIN_20 DATAIN_21
+  DATAIN_22 DATAIN_23 DATAIN_24 DATAIN_25 DATAIN_26 DATAIN_27 DATAIN_28
+  DATAIN_29 DATAIN_30 DATAIN_31 DATAIN_32 DATAIN_33 DATAIN_34 DATAIN_35
+  DATAIN_36 DATAIN_37 DATAIN_38 DATAIN_39 DATAIN_40 DATAIN_41 DATAIN_42
+  DATAIN_43 DATAIN_44 DATAIN_45 DATAIN_46 DATAIN_47 DATAIN_48 DATAIN_49
+  DATAIN_50 DATAIN_51 DATAIN_52 DATAIN_53 DATAIN_54 DATAIN_55 DATAIN_56
+  DATAIN_57 DATAIN_58 DATAIN_59 DATAIN_60 DATAIN_61 DATAIN_62 DATAIN_63 GDL_0
+  GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12
+  GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22
+  GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32
+  GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42
+  GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52
+  GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62
+  GDL_63 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_A_4 NBIT_A_5 NBIT_A_6
+  NBIT_A_7 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11 NBIT_A_12 NBIT_A_13
+  NBIT_A_14 NBIT_A_15 NBIT_A_16 NBIT_A_17 NBIT_A_18 NBIT_A_19 NBIT_A_20
+  NBIT_A_21 NBIT_A_22 NBIT_A_23 NBIT_A_24 NBIT_A_25 NBIT_A_26 NBIT_A_27
+  NBIT_A_28 NBIT_A_29 NBIT_A_30 NBIT_A_31 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_A_36 NBIT_A_37 NBIT_A_38 NBIT_A_39 NBIT_A_40 NBIT_A_41
+  NBIT_A_42 NBIT_A_43 NBIT_A_44 NBIT_A_45 NBIT_A_46 NBIT_A_47 NBIT_A_48
+  NBIT_A_49 NBIT_A_50 NBIT_A_51 NBIT_A_52 NBIT_A_53 NBIT_A_54 NBIT_A_55
+  NBIT_A_56 NBIT_A_57 NBIT_A_58 NBIT_A_59 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_A_64 NBIT_A_65 NBIT_A_66 NBIT_A_67 NBIT_A_68 NBIT_A_69
+  NBIT_A_70 NBIT_A_71 NBIT_A_72 NBIT_A_73 NBIT_A_74 NBIT_A_75 NBIT_A_76
+  NBIT_A_77 NBIT_A_78 NBIT_A_79 NBIT_A_80 NBIT_A_81 NBIT_A_82 NBIT_A_83
+  NBIT_A_84 NBIT_A_85 NBIT_A_86 NBIT_A_87 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_A_92 NBIT_A_93 NBIT_A_94 NBIT_A_95 NBIT_A_96 NBIT_A_97
+  NBIT_A_98 NBIT_A_99 NBIT_A_100 NBIT_A_101 NBIT_A_102 NBIT_A_103 NBIT_A_104
+  NBIT_A_105 NBIT_A_106 NBIT_A_107 NBIT_A_108 NBIT_A_109 NBIT_A_110
+  NBIT_A_111 NBIT_A_112 NBIT_A_113 NBIT_A_114 NBIT_A_115 NBIT_A_116
+  NBIT_A_117 NBIT_A_118 NBIT_A_119 NBIT_A_120 NBIT_A_121 NBIT_A_122
+  NBIT_A_123 NBIT_A_124 NBIT_A_125 NBIT_A_126 NBIT_A_127 NBIT_B_0 NBIT_B_1
+  NBIT_B_2 NBIT_B_3 NBIT_B_4 NBIT_B_5 NBIT_B_6 NBIT_B_7 NBIT_B_8 NBIT_B_9
+  NBIT_B_10 NBIT_B_11 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NBIT_B_16
+  NBIT_B_17 NBIT_B_18 NBIT_B_19 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23
+  NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NBIT_B_28 NBIT_B_29 NBIT_B_30
+  NBIT_B_31 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NBIT_B_36 NBIT_B_37
+  NBIT_B_38 NBIT_B_39 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NBIT_B_44
+  NBIT_B_45 NBIT_B_46 NBIT_B_47 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51
+  NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NBIT_B_56 NBIT_B_57 NBIT_B_58
+  NBIT_B_59 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NBIT_B_64 NBIT_B_65
+  NBIT_B_66 NBIT_B_67 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NBIT_B_72
+  NBIT_B_73 NBIT_B_74 NBIT_B_75 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79
+  NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NBIT_B_84 NBIT_B_85 NBIT_B_86
+  NBIT_B_87 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NBIT_B_92 NBIT_B_93
+  NBIT_B_94 NBIT_B_95 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NBIT_B_100
+  NBIT_B_101 NBIT_B_102 NBIT_B_103 NBIT_B_104 NBIT_B_105 NBIT_B_106
+  NBIT_B_107 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NBIT_B_112
+  NBIT_B_113 NBIT_B_114 NBIT_B_115 NBIT_B_116 NBIT_B_117 NBIT_B_118
+  NBIT_B_119 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NBIT_B_124
+  NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_0 NWGSEL_1 NWGSEL_2 NWGSEL_3
+  NWGSEL_4 NWGSEL_5 NWGSEL_6 NWGSEL_7 NWGSEL_8 NWGSEL_9 NWGSEL_10 NWGSEL_11
+  NWGSEL_12 NWGSEL_13 NWGSEL_14 NWGSEL_15 NWGSEL_16 NWGSEL_17 NWGSEL_18
+  NWGSEL_19 NWGSEL_20 NWGSEL_21 NWGSEL_22 NWGSEL_23 NWGSEL_24 NWGSEL_25
+  NWGSEL_26 NWGSEL_27 NWGSEL_28 NWGSEL_29 NWGSEL_30 NWGSEL_31 NWGSEL_32
+  NWGSEL_33 NWGSEL_34 NWGSEL_35 NWGSEL_36 NWGSEL_37 NWGSEL_38 NWGSEL_39
+  NWGSEL_40 NWGSEL_41 NWGSEL_42 NWGSEL_43 NWGSEL_44 NWGSEL_45 NWGSEL_46
+  NWGSEL_47 NWGSEL_48 NWGSEL_49 NWGSEL_50 NWGSEL_51 NWGSEL_52 NWGSEL_53
+  NWGSEL_54 NWGSEL_55 NWGSEL_56 NWGSEL_57 NWGSEL_58 NWGSEL_59 NWGSEL_60
+  NWGSEL_61 NWGSEL_62 NWGSEL_63 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13
+  VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21
+  VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29
+  VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37
+  VDDCE_38 VDDCE_39 VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45
+  VDDCE_46 VDDCE_47 VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDCE_52 VDDCE_53
+  VDDCE_54 VDDCE_55 VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDCE_60 VDDCE_61
+  VDDCE_62 VDDCE_63 VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDCE_68 VDDCE_69
+  VDDCE_70 VDDCE_71 VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDCE_76 VDDCE_77
+  VDDCE_78 VDDCE_79 VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDCE_84 VDDCE_85
+  VDDCE_86 VDDCE_87 VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDCE_92 VDDCE_93
+  VDDCE_94 VDDCE_95 VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDCE_100 VDDCE_101
+  VDDCE_102 VDDCE_103 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDCE_108
+  VDDCE_109 VDDCE_110 VDDCE_111 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115
+  VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDCE_120 VDDCE_121 VDDCE_122
+  VDDCE_123 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12
+  VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21
+  VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30
+  VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDC_40 VDDC_41 VDDC_42 VDDC_43 VDDC_44 VDDC_45 VDDC_46 VDDC_47 VDDC_48
+  VDDC_49 VDDC_50 VDDC_51 VDDC_52 VDDC_53 VDDC_54 VDDC_55 VDDC_56 VDDC_57
+  VDDC_58 VDDC_59 VDDC_60 VDDC_61 VDDC_62 VDDC_63 VDDC_64 VDDC_65 VDDC_66
+  VDDC_67 VDDC_68 VDDC_69 VDDC_70 VDDC_71 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDC_76 VDDC_77 VDDC_78 VDDC_79 VDDC_80 VDDC_81 VDDC_82 VDDC_83 VDDC_84
+  VDDC_85 VDDC_86 VDDC_87 VDDC_88 VDDC_89 VDDC_90 VDDC_91 VDDC_92 VDDC_93
+  VDDC_94 VDDC_95 VDDC_96 VDDC_97 VDDC_98 VDDC_99 VDDC_100 VDDC_101 VDDC_102
+  VDDC_103 VDDC_104 VDDC_105 VDDC_106 VDDC_107 VDDC_108 VDDC_109 VDDC_110
+  VDDC_111 VDDC_112 VDDC_113 VDDC_114 VDDC_115 VDDC_116 VDDC_117 VDDC_118
+  VDDC_119 VDDC_120 VDDC_121 VDDC_122 VDDC_123 VDDC_124 VDDC_125 VDDC_126
+  VDDC_127 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103
+  VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VDDPE_108 VDDPE_109 VDDPE_110
+  VDDPE_111 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VDDPE_116 VDDPE_117
+  VDDPE_118 VDDPE_119 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VDDPE_124
+  VDDPE_125 VDDPE_126 VDDPE_127 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5
+  VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15
+  VNWC_16 VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24
+  VNWC_25 VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33
+  VNWC_34 VNWC_35 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VNWC_40 VNWC_41 VNWC_42
+  VNWC_43 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VNWC_48 VNWC_49 VNWC_50 VNWC_51
+  VNWC_52 VNWC_53 VNWC_54 VNWC_55 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VNWC_60
+  VNWC_61 VNWC_62 VNWC_63 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VNWC_68 VNWC_69
+  VNWC_70 VNWC_71 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VNWC_76 VNWC_77 VNWC_78
+  VNWC_79 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VNWC_84 VNWC_85 VNWC_86 VNWC_87
+  VNWC_88 VNWC_89 VNWC_90 VNWC_91 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VNWC_96
+  VNWC_97 VNWC_98 VNWC_99 VNWC_100 VNWC_101 VNWC_102 VNWC_103 VNWC_104
+  VNWC_105 VNWC_106 VNWC_107 VNWC_108 VNWC_109 VNWC_110 VNWC_111 VNWC_112
+  VNWC_113 VNWC_114 VNWC_115 VNWC_116 VNWC_117 VNWC_118 VNWC_119 VNWC_120
+  VNWC_121 VNWC_122 VNWC_123 VNWC_124 VNWC_125 VNWC_126 VNWC_127 VPW_0 VPW_1
+  VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13
+  VPW_14 VPW_15 VPW_16 VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23
+  VPW_24 VPW_25 VPW_26 VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33
+  VPW_34 VPW_35 VPW_36 VPW_37 VPW_38 VPW_39 VPW_40 VPW_41 VPW_42 VPW_43
+  VPW_44 VPW_45 VPW_46 VPW_47 VPW_48 VPW_49 VPW_50 VPW_51 VPW_52 VPW_53
+  VPW_54 VPW_55 VPW_56 VPW_57 VPW_58 VPW_59 VPW_60 VPW_61 VPW_62 VPW_63
+  VPW_64 VPW_65 VPW_66 VPW_67 VPW_68 VPW_69 VPW_70 VPW_71 VPW_72 VPW_73
+  VPW_74 VPW_75 VPW_76 VPW_77 VPW_78 VPW_79 VPW_80 VPW_81 VPW_82 VPW_83
+  VPW_84 VPW_85 VPW_86 VPW_87 VPW_88 VPW_89 VPW_90 VPW_91 VPW_92 VPW_93
+  VPW_94 VPW_95 VPW_96 VPW_97 VPW_98 VPW_99 VPW_100 VPW_101 VPW_102 VPW_103
+  VPW_104 VPW_105 VPW_106 VPW_107 VPW_108 VPW_109 VPW_110 VPW_111 VPW_112
+  VPW_113 VPW_114 VPW_115 VPW_116 VPW_117 VPW_118 VPW_119 VPW_120 VPW_121
+  VPW_122 VPW_123 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_A_12
+  WL_A_13 WL_A_14 WL_A_15 WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_A_28 WL_A_29 WL_A_30
+  WL_A_31 WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_A_36 WL_A_37 WL_A_38 WL_A_39
+  WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_A_48
+  WL_A_49 WL_A_50 WL_A_51 WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_0 WL_B_1 WL_B_2 WL_B_3
+  WL_B_4 WL_B_5 WL_B_6 WL_B_7 WL_B_8 WL_B_9 WL_B_10 WL_B_11 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 WL_B_16 WL_B_17 WL_B_18 WL_B_19 WL_B_20 WL_B_21 WL_B_22
+  WL_B_23 WL_B_24 WL_B_25 WL_B_26 WL_B_27 WL_B_28 WL_B_29 WL_B_30 WL_B_31
+  WL_B_32 WL_B_33 WL_B_34 WL_B_35 WL_B_36 WL_B_37 WL_B_38 WL_B_39 WL_B_40
+  WL_B_41 WL_B_42 WL_B_43 WL_B_44 WL_B_45 WL_B_46 WL_B_47 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 WL_B_52 WL_B_53 WL_B_54 WL_B_55 WL_B_56 WL_B_57 WL_B_58
+  WL_B_59 WL_B_60 WL_B_61 WL_B_62 WL_B_63
** SRAMdpw64d256CARRAY_64_32L: 65536 flat devices **
XCCB BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB0B BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB0T BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_60 WL_A_61 WL_A_62
+  WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCLSB0[10] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_40 WL_A_41 WL_A_42
+  WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCLSB0[11] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_44 WL_A_45 WL_A_46
+  WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCLSB0[12] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_48 WL_A_49 WL_A_50
+  WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCLSB0[13] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_52 WL_A_53 WL_A_54
+  WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCLSB0[14] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_56 WL_A_57 WL_A_58
+  WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCLSB0[1] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCLSB0[2] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_8 WL_A_9 WL_A_10
+  WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCLSB0[3] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_12 WL_A_13 WL_A_14
+  WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCLSB0[4] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_16 WL_A_17 WL_A_18
+  WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCLSB0[5] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_20 WL_A_21 WL_A_22
+  WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCLSB0[6] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_24 WL_A_25 WL_A_26
+  WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCLSB0[7] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_28 WL_A_29 WL_A_30
+  WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCLSB0[8] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_32 WL_A_33 WL_A_34
+  WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCLSB0[9] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_36 WL_A_37 WL_A_38
+  WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCLSB1B BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB1T BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_60 WL_A_61 WL_A_62
+  WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCLSB1[10] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_40 WL_A_41 WL_A_42
+  WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCLSB1[11] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_44 WL_A_45 WL_A_46
+  WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCLSB1[12] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_48 WL_A_49 WL_A_50
+  WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCLSB1[13] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_52 WL_A_53 WL_A_54
+  WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCLSB1[14] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_56 WL_A_57 WL_A_58
+  WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCLSB1[1] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCLSB1[2] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_8 WL_A_9 WL_A_10
+  WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCLSB1[3] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_12 WL_A_13 WL_A_14
+  WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCLSB1[4] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_16 WL_A_17 WL_A_18
+  WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCLSB1[5] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_20 WL_A_21 WL_A_22
+  WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCLSB1[6] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_24 WL_A_25 WL_A_26
+  WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCLSB1[7] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_28 WL_A_29 WL_A_30
+  WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCLSB1[8] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_32 WL_A_33 WL_A_34
+  WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCLSB1[9] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_36 WL_A_37 WL_A_38
+  WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCLSB2B BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3
+  SRAMdpw64d256CCARR4X4
XCCLSB2T BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63
+  SRAMdpw64d256CCARR4X4
XCCLSB2[10] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43
+  SRAMdpw64d256CCARR4X4
XCCLSB2[11] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47
+  SRAMdpw64d256CCARR4X4
XCCLSB2[12] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51
+  SRAMdpw64d256CCARR4X4
XCCLSB2[13] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55
+  SRAMdpw64d256CCARR4X4
XCCLSB2[14] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59
+  SRAMdpw64d256CCARR4X4
XCCLSB2[1] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7
+  SRAMdpw64d256CCARR4X4
XCCLSB2[2] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11
+  SRAMdpw64d256CCARR4X4
XCCLSB2[3] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15
+  SRAMdpw64d256CCARR4X4
XCCLSB2[4] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19
+  SRAMdpw64d256CCARR4X4
XCCLSB2[5] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23
+  SRAMdpw64d256CCARR4X4
XCCLSB2[6] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27
+  SRAMdpw64d256CCARR4X4
XCCLSB2[7] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31
+  SRAMdpw64d256CCARR4X4
XCCLSB2[8] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35
+  SRAMdpw64d256CCARR4X4
XCCLSB2[9] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39
+  SRAMdpw64d256CCARR4X4
XCCLSB3B BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB3T BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCLSB3[10] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCLSB3[11] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCLSB3[12] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCLSB3[13] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCLSB3[14] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCLSB3[1] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCCLSB3[2] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCLSB3[3] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCLSB3[4] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCLSB3[5] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCLSB3[6] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCLSB3[7] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCLSB3[8] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCLSB3[9] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB0B BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113 BIT_B_114
+  BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB0T BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113 BIT_B_114
+  BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB0[10] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB0[11] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB0[12] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB0[13] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB0[14] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB0[1] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB0[2] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB0[3] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB0[4] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB0[5] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB0[6] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB0[7] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB0[8] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB0[9] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB1B BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117 BIT_B_118
+  BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB1T BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117 BIT_B_118
+  BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB1[10] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB1[11] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB1[12] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB1[13] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB1[14] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB1[1] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB1[2] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB1[3] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB1[4] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB1[5] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB1[6] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB1[7] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB1[8] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB1[9] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB2B BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121 BIT_B_122
+  BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB2T BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121 BIT_B_122
+  BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB2[10] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB2[11] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB2[12] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB2[13] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB2[14] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB2[1] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB2[2] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB2[3] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB2[4] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB2[5] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB2[6] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB2[7] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB2[8] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB2[9] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB3B BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125 BIT_B_126
+  BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB3T BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125 BIT_B_126
+  BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB3[10] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB3[11] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB3[12] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB3[13] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB3[14] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB3[1] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB3[2] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB3[3] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB3[4] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB3[5] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB3[6] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB3[7] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB3[8] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB3[9] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCT BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[10] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[10]B BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[10]T BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[10][10] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[10][11] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[10][12] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[10][13] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[10][14] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[10][1] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[10][2] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[10][3] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[10][4] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[10][5] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[10][6] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[10][7] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[10][8] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[10][9] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[11] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[11]B BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[11]T BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[11][10] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[11][11] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[11][12] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[11][13] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[11][14] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[11][1] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[11][2] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[11][3] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[11][4] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[11][5] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[11][6] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[11][7] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[11][8] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[11][9] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[12] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[12]B BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[12]T BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[12][10] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[12][11] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[12][12] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[12][13] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[12][14] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[12][1] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[12][2] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[12][3] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[12][4] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[12][5] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[12][6] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[12][7] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[12][8] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[12][9] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[13] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[13]B BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[13]T BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[13][10] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[13][11] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[13][12] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[13][13] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[13][14] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[13][1] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[13][2] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[13][3] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[13][4] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[13][5] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[13][6] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[13][7] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[13][8] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[13][9] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[14] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[14]B BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[14]T BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[14][10] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[14][11] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[14][12] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[14][13] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[14][14] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[14][1] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[14][2] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[14][3] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[14][4] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[14][5] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[14][6] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[14][7] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[14][8] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[14][9] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[15]B BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[15]T BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[15][10] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[15][11] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[15][12] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[15][13] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[15][14] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[15][1] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[15][2] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[15][3] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[15][4] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[15][5] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[15][6] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[15][7] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[15][8] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[15][9] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[16]B BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[16]T BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[16][10] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[16][11] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[16][12] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[16][13] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[16][14] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[16][1] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[16][2] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[16][3] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[16][4] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[16][5] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[16][6] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[16][7] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[16][8] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[16][9] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[17]B BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[17]T BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[17][10] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[17][11] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[17][12] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[17][13] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[17][14] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[17][1] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[17][2] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[17][3] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[17][4] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[17][5] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[17][6] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[17][7] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[17][8] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[17][9] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[18]B BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[18]T BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[18][10] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[18][11] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[18][12] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[18][13] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[18][14] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[18][1] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[18][2] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[18][3] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[18][4] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[18][5] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[18][6] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[18][7] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[18][8] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[18][9] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[19]B BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[19]T BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[19][10] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[19][11] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[19][12] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[19][13] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[19][14] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[19][1] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[19][2] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[19][3] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[19][4] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[19][5] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[19][6] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[19][7] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[19][8] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[19][9] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[1] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCC[20]B BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[20]T BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[20][10] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[20][11] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[20][12] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[20][13] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[20][14] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[20][1] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[20][2] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[20][3] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[20][4] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[20][5] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[20][6] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[20][7] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[20][8] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[20][9] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[21]B BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[21]T BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[21][10] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[21][11] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[21][12] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[21][13] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[21][14] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[21][1] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[21][2] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[21][3] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[21][4] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[21][5] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[21][6] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[21][7] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[21][8] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[21][9] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[22]B BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[22]T BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[22][10] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[22][11] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[22][12] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[22][13] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[22][14] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[22][1] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[22][2] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[22][3] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[22][4] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[22][5] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[22][6] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[22][7] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[22][8] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[22][9] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[23]B BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[23]T BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[23][10] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[23][11] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[23][12] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[23][13] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[23][14] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[23][1] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[23][2] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[23][3] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[23][4] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[23][5] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[23][6] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[23][7] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[23][8] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[23][9] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[24]B BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[24]T BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[24][10] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[24][11] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[24][12] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[24][13] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[24][14] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[24][1] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[24][2] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[24][3] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[24][4] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[24][5] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[24][6] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[24][7] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[24][8] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[24][9] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[25]B BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101 BIT_B_102
+  BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCC[25]T BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101 BIT_B_102
+  BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[25][10] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[25][11] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[25][12] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[25][13] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[25][14] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[25][1] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCC[25][2] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[25][3] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[25][4] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[25][5] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[25][6] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[25][7] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[25][8] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[25][9] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[26]B BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105 BIT_B_106
+  BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCC[26]T BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105 BIT_B_106
+  BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[26][10] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[26][11] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[26][12] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[26][13] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[26][14] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[26][1] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCC[26][2] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[26][3] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[26][4] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[26][5] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[26][6] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[26][7] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[26][8] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[26][9] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[2] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[3] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[4] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[4]B BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[4]T BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[4][10] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[4][11] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[4][12] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[4][13] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[4][14] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[4][1] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[4][2] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[4][3] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[4][4] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[4][5] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[4][6] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[4][7] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[4][8] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[4][9] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[5] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[5]B BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[5]T BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[5][10] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[5][11] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[5][12] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[5][13] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[5][14] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[5][1] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[5][2] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[5][3] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[5][4] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[5][5] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[5][6] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[5][7] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[5][8] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[5][9] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[6] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[6]B BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[6]T BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[6][10] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[6][11] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[6][12] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[6][13] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[6][14] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[6][1] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[6][2] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[6][3] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[6][4] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[6][5] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[6][6] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[6][7] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[6][8] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[6][9] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[7] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[7]B BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[7]T BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[7][10] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[7][11] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[7][12] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[7][13] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[7][14] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[7][1] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[7][2] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[7][3] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[7][4] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[7][5] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[7][6] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[7][7] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[7][8] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[7][9] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[8] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[8]B BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[8]T BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[8][10] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[8][11] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[8][12] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[8][13] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[8][14] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[8][1] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[8][2] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[8][3] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[8][4] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[8][5] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[8][6] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[8][7] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[8][8] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[8][9] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[9] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[9]B BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[9]T BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[9][10] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[9][11] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[9][12] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[9][13] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[9][14] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[9][1] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[9][2] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[9][3] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[9][4] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[9][5] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[9][6] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[9][7] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[9][8] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[9][9] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
.ENDS SRAMdpw64d256CARRAY_64_32L
****
.SUBCKT SRAMdpw64d256CARRAY_64_32R BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_A_4
+  BIT_A_5 BIT_A_6 BIT_A_7 BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_A_12 BIT_A_13
+  BIT_A_14 BIT_A_15 BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_A_20 BIT_A_21
+  BIT_A_22 BIT_A_23 BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_A_28 BIT_A_29
+  BIT_A_30 BIT_A_31 BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_A_36 BIT_A_37
+  BIT_A_38 BIT_A_39 BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_A_44 BIT_A_45
+  BIT_A_46 BIT_A_47 BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_A_52 BIT_A_53
+  BIT_A_54 BIT_A_55 BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_A_60 BIT_A_61
+  BIT_A_62 BIT_A_63 BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_A_68 BIT_A_69
+  BIT_A_70 BIT_A_71 BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_A_76 BIT_A_77
+  BIT_A_78 BIT_A_79 BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_A_84 BIT_A_85
+  BIT_A_86 BIT_A_87 BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_A_92 BIT_A_93
+  BIT_A_94 BIT_A_95 BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_A_100 BIT_A_101
+  BIT_A_102 BIT_A_103 BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_A_108
+  BIT_A_109 BIT_A_110 BIT_A_111 BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115
+  BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_A_120 BIT_A_121 BIT_A_122
+  BIT_A_123 BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_0 BIT_B_1 BIT_B_2
+  BIT_B_3 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  BIT_B_12 BIT_B_13 BIT_B_14 BIT_B_15 BIT_B_16 BIT_B_17 BIT_B_18 BIT_B_19
+  BIT_B_20 BIT_B_21 BIT_B_22 BIT_B_23 BIT_B_24 BIT_B_25 BIT_B_26 BIT_B_27
+  BIT_B_28 BIT_B_29 BIT_B_30 BIT_B_31 BIT_B_32 BIT_B_33 BIT_B_34 BIT_B_35
+  BIT_B_36 BIT_B_37 BIT_B_38 BIT_B_39 BIT_B_40 BIT_B_41 BIT_B_42 BIT_B_43
+  BIT_B_44 BIT_B_45 BIT_B_46 BIT_B_47 BIT_B_48 BIT_B_49 BIT_B_50 BIT_B_51
+  BIT_B_52 BIT_B_53 BIT_B_54 BIT_B_55 BIT_B_56 BIT_B_57 BIT_B_58 BIT_B_59
+  BIT_B_60 BIT_B_61 BIT_B_62 BIT_B_63 BIT_B_64 BIT_B_65 BIT_B_66 BIT_B_67
+  BIT_B_68 BIT_B_69 BIT_B_70 BIT_B_71 BIT_B_72 BIT_B_73 BIT_B_74 BIT_B_75
+  BIT_B_76 BIT_B_77 BIT_B_78 BIT_B_79 BIT_B_80 BIT_B_81 BIT_B_82 BIT_B_83
+  BIT_B_84 BIT_B_85 BIT_B_86 BIT_B_87 BIT_B_88 BIT_B_89 BIT_B_90 BIT_B_91
+  BIT_B_92 BIT_B_93 BIT_B_94 BIT_B_95 BIT_B_96 BIT_B_97 BIT_B_98 BIT_B_99
+  BIT_B_100 BIT_B_101 BIT_B_102 BIT_B_103 BIT_B_104 BIT_B_105 BIT_B_106
+  BIT_B_107 BIT_B_108 BIT_B_109 BIT_B_110 BIT_B_111 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 BIT_B_116 BIT_B_117 BIT_B_118 BIT_B_119 BIT_B_120
+  BIT_B_121 BIT_B_122 BIT_B_123 BIT_B_124 BIT_B_125 BIT_B_126 BIT_B_127
+  DATAIN_0 DATAIN_1 DATAIN_2 DATAIN_3 DATAIN_4 DATAIN_5 DATAIN_6 DATAIN_7
+  DATAIN_8 DATAIN_9 DATAIN_10 DATAIN_11 DATAIN_12 DATAIN_13 DATAIN_14
+  DATAIN_15 DATAIN_16 DATAIN_17 DATAIN_18 DATAIN_19 DATAIN_20 DATAIN_21
+  DATAIN_22 DATAIN_23 DATAIN_24 DATAIN_25 DATAIN_26 DATAIN_27 DATAIN_28
+  DATAIN_29 DATAIN_30 DATAIN_31 DATAIN_32 DATAIN_33 DATAIN_34 DATAIN_35
+  DATAIN_36 DATAIN_37 DATAIN_38 DATAIN_39 DATAIN_40 DATAIN_41 DATAIN_42
+  DATAIN_43 DATAIN_44 DATAIN_45 DATAIN_46 DATAIN_47 DATAIN_48 DATAIN_49
+  DATAIN_50 DATAIN_51 DATAIN_52 DATAIN_53 DATAIN_54 DATAIN_55 DATAIN_56
+  DATAIN_57 DATAIN_58 DATAIN_59 DATAIN_60 DATAIN_61 DATAIN_62 DATAIN_63 GDL_0
+  GDL_1 GDL_2 GDL_3 GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12
+  GDL_13 GDL_14 GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22
+  GDL_23 GDL_24 GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32
+  GDL_33 GDL_34 GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42
+  GDL_43 GDL_44 GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52
+  GDL_53 GDL_54 GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62
+  GDL_63 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_A_4 NBIT_A_5 NBIT_A_6
+  NBIT_A_7 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11 NBIT_A_12 NBIT_A_13
+  NBIT_A_14 NBIT_A_15 NBIT_A_16 NBIT_A_17 NBIT_A_18 NBIT_A_19 NBIT_A_20
+  NBIT_A_21 NBIT_A_22 NBIT_A_23 NBIT_A_24 NBIT_A_25 NBIT_A_26 NBIT_A_27
+  NBIT_A_28 NBIT_A_29 NBIT_A_30 NBIT_A_31 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_A_36 NBIT_A_37 NBIT_A_38 NBIT_A_39 NBIT_A_40 NBIT_A_41
+  NBIT_A_42 NBIT_A_43 NBIT_A_44 NBIT_A_45 NBIT_A_46 NBIT_A_47 NBIT_A_48
+  NBIT_A_49 NBIT_A_50 NBIT_A_51 NBIT_A_52 NBIT_A_53 NBIT_A_54 NBIT_A_55
+  NBIT_A_56 NBIT_A_57 NBIT_A_58 NBIT_A_59 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_A_64 NBIT_A_65 NBIT_A_66 NBIT_A_67 NBIT_A_68 NBIT_A_69
+  NBIT_A_70 NBIT_A_71 NBIT_A_72 NBIT_A_73 NBIT_A_74 NBIT_A_75 NBIT_A_76
+  NBIT_A_77 NBIT_A_78 NBIT_A_79 NBIT_A_80 NBIT_A_81 NBIT_A_82 NBIT_A_83
+  NBIT_A_84 NBIT_A_85 NBIT_A_86 NBIT_A_87 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_A_92 NBIT_A_93 NBIT_A_94 NBIT_A_95 NBIT_A_96 NBIT_A_97
+  NBIT_A_98 NBIT_A_99 NBIT_A_100 NBIT_A_101 NBIT_A_102 NBIT_A_103 NBIT_A_104
+  NBIT_A_105 NBIT_A_106 NBIT_A_107 NBIT_A_108 NBIT_A_109 NBIT_A_110
+  NBIT_A_111 NBIT_A_112 NBIT_A_113 NBIT_A_114 NBIT_A_115 NBIT_A_116
+  NBIT_A_117 NBIT_A_118 NBIT_A_119 NBIT_A_120 NBIT_A_121 NBIT_A_122
+  NBIT_A_123 NBIT_A_124 NBIT_A_125 NBIT_A_126 NBIT_A_127 NBIT_B_0 NBIT_B_1
+  NBIT_B_2 NBIT_B_3 NBIT_B_4 NBIT_B_5 NBIT_B_6 NBIT_B_7 NBIT_B_8 NBIT_B_9
+  NBIT_B_10 NBIT_B_11 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NBIT_B_16
+  NBIT_B_17 NBIT_B_18 NBIT_B_19 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23
+  NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NBIT_B_28 NBIT_B_29 NBIT_B_30
+  NBIT_B_31 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NBIT_B_36 NBIT_B_37
+  NBIT_B_38 NBIT_B_39 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NBIT_B_44
+  NBIT_B_45 NBIT_B_46 NBIT_B_47 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51
+  NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NBIT_B_56 NBIT_B_57 NBIT_B_58
+  NBIT_B_59 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NBIT_B_64 NBIT_B_65
+  NBIT_B_66 NBIT_B_67 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NBIT_B_72
+  NBIT_B_73 NBIT_B_74 NBIT_B_75 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79
+  NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NBIT_B_84 NBIT_B_85 NBIT_B_86
+  NBIT_B_87 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NBIT_B_92 NBIT_B_93
+  NBIT_B_94 NBIT_B_95 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NBIT_B_100
+  NBIT_B_101 NBIT_B_102 NBIT_B_103 NBIT_B_104 NBIT_B_105 NBIT_B_106
+  NBIT_B_107 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NBIT_B_112
+  NBIT_B_113 NBIT_B_114 NBIT_B_115 NBIT_B_116 NBIT_B_117 NBIT_B_118
+  NBIT_B_119 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NBIT_B_124
+  NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_0 NWGSEL_1 NWGSEL_2 NWGSEL_3
+  NWGSEL_4 NWGSEL_5 NWGSEL_6 NWGSEL_7 NWGSEL_8 NWGSEL_9 NWGSEL_10 NWGSEL_11
+  NWGSEL_12 NWGSEL_13 NWGSEL_14 NWGSEL_15 NWGSEL_16 NWGSEL_17 NWGSEL_18
+  NWGSEL_19 NWGSEL_20 NWGSEL_21 NWGSEL_22 NWGSEL_23 NWGSEL_24 NWGSEL_25
+  NWGSEL_26 NWGSEL_27 NWGSEL_28 NWGSEL_29 NWGSEL_30 NWGSEL_31 NWGSEL_32
+  NWGSEL_33 NWGSEL_34 NWGSEL_35 NWGSEL_36 NWGSEL_37 NWGSEL_38 NWGSEL_39
+  NWGSEL_40 NWGSEL_41 NWGSEL_42 NWGSEL_43 NWGSEL_44 NWGSEL_45 NWGSEL_46
+  NWGSEL_47 NWGSEL_48 NWGSEL_49 NWGSEL_50 NWGSEL_51 NWGSEL_52 NWGSEL_53
+  NWGSEL_54 NWGSEL_55 NWGSEL_56 NWGSEL_57 NWGSEL_58 NWGSEL_59 NWGSEL_60
+  NWGSEL_61 NWGSEL_62 NWGSEL_63 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4
+  VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13
+  VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21
+  VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29
+  VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37
+  VDDCE_38 VDDCE_39 VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45
+  VDDCE_46 VDDCE_47 VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDCE_52 VDDCE_53
+  VDDCE_54 VDDCE_55 VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDCE_60 VDDCE_61
+  VDDCE_62 VDDCE_63 VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDCE_68 VDDCE_69
+  VDDCE_70 VDDCE_71 VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDCE_76 VDDCE_77
+  VDDCE_78 VDDCE_79 VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDCE_84 VDDCE_85
+  VDDCE_86 VDDCE_87 VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDCE_92 VDDCE_93
+  VDDCE_94 VDDCE_95 VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDCE_100 VDDCE_101
+  VDDCE_102 VDDCE_103 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDCE_108
+  VDDCE_109 VDDCE_110 VDDCE_111 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115
+  VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDCE_120 VDDCE_121 VDDCE_122
+  VDDCE_123 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_0 VDDC_1 VDDC_2
+  VDDC_3 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12
+  VDDC_13 VDDC_14 VDDC_15 VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21
+  VDDC_22 VDDC_23 VDDC_24 VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30
+  VDDC_31 VDDC_32 VDDC_33 VDDC_34 VDDC_35 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDC_40 VDDC_41 VDDC_42 VDDC_43 VDDC_44 VDDC_45 VDDC_46 VDDC_47 VDDC_48
+  VDDC_49 VDDC_50 VDDC_51 VDDC_52 VDDC_53 VDDC_54 VDDC_55 VDDC_56 VDDC_57
+  VDDC_58 VDDC_59 VDDC_60 VDDC_61 VDDC_62 VDDC_63 VDDC_64 VDDC_65 VDDC_66
+  VDDC_67 VDDC_68 VDDC_69 VDDC_70 VDDC_71 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDC_76 VDDC_77 VDDC_78 VDDC_79 VDDC_80 VDDC_81 VDDC_82 VDDC_83 VDDC_84
+  VDDC_85 VDDC_86 VDDC_87 VDDC_88 VDDC_89 VDDC_90 VDDC_91 VDDC_92 VDDC_93
+  VDDC_94 VDDC_95 VDDC_96 VDDC_97 VDDC_98 VDDC_99 VDDC_100 VDDC_101 VDDC_102
+  VDDC_103 VDDC_104 VDDC_105 VDDC_106 VDDC_107 VDDC_108 VDDC_109 VDDC_110
+  VDDC_111 VDDC_112 VDDC_113 VDDC_114 VDDC_115 VDDC_116 VDDC_117 VDDC_118
+  VDDC_119 VDDC_120 VDDC_121 VDDC_122 VDDC_123 VDDC_124 VDDC_125 VDDC_126
+  VDDC_127 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103
+  VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VDDPE_108 VDDPE_109 VDDPE_110
+  VDDPE_111 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VDDPE_116 VDDPE_117
+  VDDPE_118 VDDPE_119 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VDDPE_124
+  VDDPE_125 VDDPE_126 VDDPE_127 VNWC_0 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5
+  VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15
+  VNWC_16 VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24
+  VNWC_25 VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33
+  VNWC_34 VNWC_35 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VNWC_40 VNWC_41 VNWC_42
+  VNWC_43 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VNWC_48 VNWC_49 VNWC_50 VNWC_51
+  VNWC_52 VNWC_53 VNWC_54 VNWC_55 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VNWC_60
+  VNWC_61 VNWC_62 VNWC_63 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VNWC_68 VNWC_69
+  VNWC_70 VNWC_71 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VNWC_76 VNWC_77 VNWC_78
+  VNWC_79 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VNWC_84 VNWC_85 VNWC_86 VNWC_87
+  VNWC_88 VNWC_89 VNWC_90 VNWC_91 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VNWC_96
+  VNWC_97 VNWC_98 VNWC_99 VNWC_100 VNWC_101 VNWC_102 VNWC_103 VNWC_104
+  VNWC_105 VNWC_106 VNWC_107 VNWC_108 VNWC_109 VNWC_110 VNWC_111 VNWC_112
+  VNWC_113 VNWC_114 VNWC_115 VNWC_116 VNWC_117 VNWC_118 VNWC_119 VNWC_120
+  VNWC_121 VNWC_122 VNWC_123 VNWC_124 VNWC_125 VNWC_126 VNWC_127 VPW_0 VPW_1
+  VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13
+  VPW_14 VPW_15 VPW_16 VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23
+  VPW_24 VPW_25 VPW_26 VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33
+  VPW_34 VPW_35 VPW_36 VPW_37 VPW_38 VPW_39 VPW_40 VPW_41 VPW_42 VPW_43
+  VPW_44 VPW_45 VPW_46 VPW_47 VPW_48 VPW_49 VPW_50 VPW_51 VPW_52 VPW_53
+  VPW_54 VPW_55 VPW_56 VPW_57 VPW_58 VPW_59 VPW_60 VPW_61 VPW_62 VPW_63
+  VPW_64 VPW_65 VPW_66 VPW_67 VPW_68 VPW_69 VPW_70 VPW_71 VPW_72 VPW_73
+  VPW_74 VPW_75 VPW_76 VPW_77 VPW_78 VPW_79 VPW_80 VPW_81 VPW_82 VPW_83
+  VPW_84 VPW_85 VPW_86 VPW_87 VPW_88 VPW_89 VPW_90 VPW_91 VPW_92 VPW_93
+  VPW_94 VPW_95 VPW_96 VPW_97 VPW_98 VPW_99 VPW_100 VPW_101 VPW_102 VPW_103
+  VPW_104 VPW_105 VPW_106 VPW_107 VPW_108 VPW_109 VPW_110 VPW_111 VPW_112
+  VPW_113 VPW_114 VPW_115 VPW_116 VPW_117 VPW_118 VPW_119 VPW_120 VPW_121
+  VPW_122 VPW_123 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_A_12
+  WL_A_13 WL_A_14 WL_A_15 WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_A_28 WL_A_29 WL_A_30
+  WL_A_31 WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_A_36 WL_A_37 WL_A_38 WL_A_39
+  WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_A_48
+  WL_A_49 WL_A_50 WL_A_51 WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_0 WL_B_1 WL_B_2 WL_B_3
+  WL_B_4 WL_B_5 WL_B_6 WL_B_7 WL_B_8 WL_B_9 WL_B_10 WL_B_11 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 WL_B_16 WL_B_17 WL_B_18 WL_B_19 WL_B_20 WL_B_21 WL_B_22
+  WL_B_23 WL_B_24 WL_B_25 WL_B_26 WL_B_27 WL_B_28 WL_B_29 WL_B_30 WL_B_31
+  WL_B_32 WL_B_33 WL_B_34 WL_B_35 WL_B_36 WL_B_37 WL_B_38 WL_B_39 WL_B_40
+  WL_B_41 WL_B_42 WL_B_43 WL_B_44 WL_B_45 WL_B_46 WL_B_47 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 WL_B_52 WL_B_53 WL_B_54 WL_B_55 WL_B_56 WL_B_57 WL_B_58
+  WL_B_59 WL_B_60 WL_B_61 WL_B_62 WL_B_63
** SRAMdpw64d256CARRAY_64_32R: 65536 flat devices **
XCCB BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB0B BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB0T BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_60 WL_A_61 WL_A_62
+  WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCLSB0[10] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_40 WL_A_41 WL_A_42
+  WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCLSB0[11] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_44 WL_A_45 WL_A_46
+  WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCLSB0[12] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_48 WL_A_49 WL_A_50
+  WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCLSB0[13] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_52 WL_A_53 WL_A_54
+  WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCLSB0[14] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_56 WL_A_57 WL_A_58
+  WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCLSB0[1] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCLSB0[2] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_8 WL_A_9 WL_A_10
+  WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCLSB0[3] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_12 WL_A_13 WL_A_14
+  WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCLSB0[4] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_16 WL_A_17 WL_A_18
+  WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCLSB0[5] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_20 WL_A_21 WL_A_22
+  WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCLSB0[6] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_24 WL_A_25 WL_A_26
+  WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCLSB0[7] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_28 WL_A_29 WL_A_30
+  WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCLSB0[8] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_32 WL_A_33 WL_A_34
+  WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCLSB0[9] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3
+  DATAIN_0 DATAIN_1 GDL_0 GDL_1 NBIT_A_0 NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NWGSEL_0 NWGSEL_1 VDDCE_0 VDDCE_1 VDDCE_2
+  VDDCE_3 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VNWC_0
+  VNWC_1 VNWC_2 VNWC_3 VPW_0 VPW_1 VPW_2 VPW_3 VSSE WL_A_36 WL_A_37 WL_A_38
+  WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCLSB1B BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB1T BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_60 WL_A_61 WL_A_62
+  WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCLSB1[10] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_40 WL_A_41 WL_A_42
+  WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCLSB1[11] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_44 WL_A_45 WL_A_46
+  WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCLSB1[12] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_48 WL_A_49 WL_A_50
+  WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCLSB1[13] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_52 WL_A_53 WL_A_54
+  WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCLSB1[14] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_56 WL_A_57 WL_A_58
+  WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCLSB1[1] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCLSB1[2] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_8 WL_A_9 WL_A_10
+  WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCLSB1[3] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_12 WL_A_13 WL_A_14
+  WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCLSB1[4] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_16 WL_A_17 WL_A_18
+  WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCLSB1[5] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_20 WL_A_21 WL_A_22
+  WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCLSB1[6] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_24 WL_A_25 WL_A_26
+  WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCLSB1[7] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_28 WL_A_29 WL_A_30
+  WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCLSB1[8] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_32 WL_A_33 WL_A_34
+  WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCLSB1[9] BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7
+  DATAIN_2 DATAIN_3 GDL_2 GDL_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_B_4
+  NBIT_B_5 NBIT_B_6 NBIT_B_7 NWGSEL_2 NWGSEL_3 VDDCE_4 VDDCE_5 VDDCE_6
+  VDDCE_7 VDDC_4 VDDC_5 VDDC_6 VDDC_7 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VNWC_4
+  VNWC_5 VNWC_6 VNWC_7 VPW_4 VPW_5 VPW_6 VPW_7 VSSE WL_A_36 WL_A_37 WL_A_38
+  WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCLSB2B BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3
+  SRAMdpw64d256CCARR4X4
XCCLSB2T BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63
+  SRAMdpw64d256CCARR4X4
XCCLSB2[10] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43
+  SRAMdpw64d256CCARR4X4
XCCLSB2[11] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47
+  SRAMdpw64d256CCARR4X4
XCCLSB2[12] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51
+  SRAMdpw64d256CCARR4X4
XCCLSB2[13] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55
+  SRAMdpw64d256CCARR4X4
XCCLSB2[14] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10
+  NBIT_A_11 NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8
+  VDDCE_9 VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11
+  VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59
+  SRAMdpw64d256CCARR4X4
XCCLSB2[1] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7
+  SRAMdpw64d256CCARR4X4
XCCLSB2[2] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11
+  SRAMdpw64d256CCARR4X4
XCCLSB2[3] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15
+  SRAMdpw64d256CCARR4X4
XCCLSB2[4] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19
+  SRAMdpw64d256CCARR4X4
XCCLSB2[5] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23
+  SRAMdpw64d256CCARR4X4
XCCLSB2[6] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27
+  SRAMdpw64d256CCARR4X4
XCCLSB2[7] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31
+  SRAMdpw64d256CCARR4X4
XCCLSB2[8] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35
+  SRAMdpw64d256CCARR4X4
XCCLSB2[9] BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11
+  DATAIN_4 DATAIN_5 GDL_4 GDL_5 NBIT_A_8 NBIT_A_9 NBIT_A_10 NBIT_A_11
+  NBIT_B_8 NBIT_B_9 NBIT_B_10 NBIT_B_11 NWGSEL_4 NWGSEL_5 VDDCE_8 VDDCE_9
+  VDDCE_10 VDDCE_11 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VPW_8 VPW_9 VPW_10 VPW_11 VSSE
+  WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39
+  SRAMdpw64d256CCARR4X4
XCCLSB3B BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCCLSB3T BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCLSB3[10] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCLSB3[11] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCLSB3[12] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCLSB3[13] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCLSB3[14] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCLSB3[1] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCCLSB3[2] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCLSB3[3] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCLSB3[4] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCLSB3[5] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCLSB3[6] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCLSB3[7] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCLSB3[8] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCLSB3[9] BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15 BIT_B_12 BIT_B_13 BIT_B_14
+  BIT_B_15 DATAIN_6 DATAIN_7 GDL_6 GDL_7 NBIT_A_12 NBIT_A_13 NBIT_A_14
+  NBIT_A_15 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NWGSEL_6 NWGSEL_7
+  VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VPW_12
+  VPW_13 VPW_14 VPW_15 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB0B BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113 BIT_B_114
+  BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB0T BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113 BIT_B_114
+  BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB0[10] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB0[11] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB0[12] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB0[13] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB0[14] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB0[1] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB0[2] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB0[3] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB0[4] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB0[5] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB0[6] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB0[7] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB0[8] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB0[9] BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_B_112 BIT_B_113
+  BIT_B_114 BIT_B_115 DATAIN_56 DATAIN_57 GDL_56 GDL_57 NBIT_A_112 NBIT_A_113
+  NBIT_A_114 NBIT_A_115 NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NWGSEL_56
+  NWGSEL_57 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDC_112 VDDC_113
+  VDDC_114 VDDC_115 VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VNWC_112 VNWC_113
+  VNWC_114 VNWC_115 VPW_112 VPW_113 VPW_114 VPW_115 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB1B BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117 BIT_B_118
+  BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB1T BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117 BIT_B_118
+  BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB1[10] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB1[11] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB1[12] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB1[13] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB1[14] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB1[1] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB1[2] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB1[3] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB1[4] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB1[5] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB1[6] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB1[7] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB1[8] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB1[9] BIT_A_116 BIT_A_117 BIT_A_118 BIT_A_119 BIT_B_116 BIT_B_117
+  BIT_B_118 BIT_B_119 DATAIN_58 DATAIN_59 GDL_58 GDL_59 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119 NWGSEL_58
+  NWGSEL_59 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119 VDDC_116 VDDC_117
+  VDDC_118 VDDC_119 VDDPE_116 VDDPE_117 VDDPE_118 VDDPE_119 VNWC_116 VNWC_117
+  VNWC_118 VNWC_119 VPW_116 VPW_117 VPW_118 VPW_119 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB2B BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121 BIT_B_122
+  BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB2T BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121 BIT_B_122
+  BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB2[10] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB2[11] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB2[12] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB2[13] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB2[14] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB2[1] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB2[2] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB2[3] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB2[4] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB2[5] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB2[6] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB2[7] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB2[8] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB2[9] BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_B_120 BIT_B_121
+  BIT_B_122 BIT_B_123 DATAIN_60 DATAIN_61 GDL_60 GDL_61 NBIT_A_120 NBIT_A_121
+  NBIT_A_122 NBIT_A_123 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NWGSEL_60
+  NWGSEL_61 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDC_120 VDDC_121
+  VDDC_122 VDDC_123 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VNWC_120 VNWC_121
+  VNWC_122 VNWC_123 VPW_120 VPW_121 VPW_122 VPW_123 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCMSB3B BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125 BIT_B_126
+  BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCCMSB3T BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125 BIT_B_126
+  BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCCMSB3[10] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCCMSB3[11] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCCMSB3[12] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCCMSB3[13] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCCMSB3[14] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCCMSB3[1] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCCMSB3[2] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCCMSB3[3] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCCMSB3[4] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCCMSB3[5] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCCMSB3[6] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCCMSB3[7] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCCMSB3[8] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCCMSB3[9] BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_124 BIT_B_125
+  BIT_B_126 BIT_B_127 DATAIN_62 DATAIN_63 GDL_62 GDL_63 NBIT_A_124 NBIT_A_125
+  NBIT_A_126 NBIT_A_127 NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NWGSEL_62
+  NWGSEL_63 VDDCE_124 VDDCE_125 VDDCE_126 VDDCE_127 VDDC_124 VDDC_125
+  VDDC_126 VDDC_127 VDDPE_124 VDDPE_125 VDDPE_126 VDDPE_127 VNWC_124 VNWC_125
+  VNWC_126 VNWC_127 VPW_124 VPW_125 VPW_126 VPW_127 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCCT BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[10] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[10]B BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[10]T BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[10][10] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[10][11] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[10][12] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[10][13] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[10][14] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[10][1] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[10][2] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[10][3] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[10][4] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[10][5] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[10][6] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[10][7] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[10][8] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[10][9] BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 DATAIN_20 DATAIN_21 GDL_20 GDL_21 NBIT_A_40 NBIT_A_41 NBIT_A_42
+  NBIT_A_43 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NWGSEL_20 NWGSEL_21
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDC_40 VDDC_41 VDDC_42 VDDC_43
+  VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VPW_40
+  VPW_41 VPW_42 VPW_43 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[11] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[11]B BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[11]T BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[11][10] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[11][11] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[11][12] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[11][13] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[11][14] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[11][1] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[11][2] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[11][3] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[11][4] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[11][5] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[11][6] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[11][7] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[11][8] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[11][9] BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47 BIT_B_44 BIT_B_45 BIT_B_46
+  BIT_B_47 DATAIN_22 DATAIN_23 GDL_22 GDL_23 NBIT_A_44 NBIT_A_45 NBIT_A_46
+  NBIT_A_47 NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NWGSEL_22 NWGSEL_23
+  VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDC_44 VDDC_45 VDDC_46 VDDC_47
+  VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VPW_44
+  VPW_45 VPW_46 VPW_47 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[12] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[12]B BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[12]T BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[12][10] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[12][11] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[12][12] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[12][13] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[12][14] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[12][1] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[12][2] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[12][3] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[12][4] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[12][5] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[12][6] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[12][7] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[12][8] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[12][9] BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 DATAIN_24 DATAIN_25 GDL_24 GDL_25 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NWGSEL_24 NWGSEL_25
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VPW_48
+  VPW_49 VPW_50 VPW_51 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[13] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[13]B BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[13]T BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[13][10] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[13][11] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[13][12] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[13][13] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[13][14] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[13][1] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[13][2] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[13][3] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[13][4] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[13][5] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[13][6] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[13][7] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[13][8] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[13][9] BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55 BIT_B_52 BIT_B_53 BIT_B_54
+  BIT_B_55 DATAIN_26 DATAIN_27 GDL_26 GDL_27 NBIT_A_52 NBIT_A_53 NBIT_A_54
+  NBIT_A_55 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NWGSEL_26 NWGSEL_27
+  VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDC_52 VDDC_53 VDDC_54 VDDC_55
+  VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VPW_52
+  VPW_53 VPW_54 VPW_55 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[14] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[14]B BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[14]T BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[14][10] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[14][11] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[14][12] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[14][13] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[14][14] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[14][1] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[14][2] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[14][3] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[14][4] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[14][5] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[14][6] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[14][7] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[14][8] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[14][9] BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 DATAIN_28 DATAIN_29 GDL_28 GDL_29 NBIT_A_56 NBIT_A_57 NBIT_A_58
+  NBIT_A_59 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59 NWGSEL_28 NWGSEL_29
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDC_56 VDDC_57 VDDC_58 VDDC_59
+  VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VPW_56
+  VPW_57 VPW_58 VPW_59 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[15]B BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[15]T BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[15][10] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[15][11] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[15][12] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[15][13] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[15][14] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[15][1] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[15][2] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[15][3] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[15][4] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[15][5] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[15][6] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[15][7] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[15][8] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[15][9] BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63 BIT_B_60 BIT_B_61 BIT_B_62
+  BIT_B_63 DATAIN_30 DATAIN_31 GDL_30 GDL_31 NBIT_A_60 NBIT_A_61 NBIT_A_62
+  NBIT_A_63 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NWGSEL_30 NWGSEL_31
+  VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDC_60 VDDC_61 VDDC_62 VDDC_63
+  VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VPW_60
+  VPW_61 VPW_62 VPW_63 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[16]B BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[16]T BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[16][10] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[16][11] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[16][12] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[16][13] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[16][14] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[16][1] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[16][2] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[16][3] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[16][4] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[16][5] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[16][6] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[16][7] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[16][8] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[16][9] BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 DATAIN_32 DATAIN_33 GDL_32 GDL_33 NBIT_A_64 NBIT_A_65 NBIT_A_66
+  NBIT_A_67 NBIT_B_64 NBIT_B_65 NBIT_B_66 NBIT_B_67 NWGSEL_32 NWGSEL_33
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDC_64 VDDC_65 VDDC_66 VDDC_67
+  VDDPE_64 VDDPE_65 VDDPE_66 VDDPE_67 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VPW_64
+  VPW_65 VPW_66 VPW_67 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[17]B BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[17]T BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[17][10] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[17][11] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[17][12] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[17][13] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[17][14] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[17][1] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[17][2] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[17][3] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[17][4] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[17][5] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[17][6] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[17][7] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[17][8] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[17][9] BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71 BIT_B_68 BIT_B_69 BIT_B_70
+  BIT_B_71 DATAIN_34 DATAIN_35 GDL_34 GDL_35 NBIT_A_68 NBIT_A_69 NBIT_A_70
+  NBIT_A_71 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NWGSEL_34 NWGSEL_35
+  VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDC_68 VDDC_69 VDDC_70 VDDC_71
+  VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VPW_68
+  VPW_69 VPW_70 VPW_71 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[18]B BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[18]T BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[18][10] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[18][11] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[18][12] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[18][13] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[18][14] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[18][1] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[18][2] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[18][3] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[18][4] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[18][5] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[18][6] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[18][7] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[18][8] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[18][9] BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 DATAIN_36 DATAIN_37 GDL_36 GDL_37 NBIT_A_72 NBIT_A_73 NBIT_A_74
+  NBIT_A_75 NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NWGSEL_36 NWGSEL_37
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDC_72 VDDC_73 VDDC_74 VDDC_75
+  VDDPE_72 VDDPE_73 VDDPE_74 VDDPE_75 VNWC_72 VNWC_73 VNWC_74 VNWC_75 VPW_72
+  VPW_73 VPW_74 VPW_75 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[19]B BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[19]T BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[19][10] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[19][11] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[19][12] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[19][13] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[19][14] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[19][1] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[19][2] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[19][3] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[19][4] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[19][5] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[19][6] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[19][7] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[19][8] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[19][9] BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79 BIT_B_76 BIT_B_77 BIT_B_78
+  BIT_B_79 DATAIN_38 DATAIN_39 GDL_38 GDL_39 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NWGSEL_38 NWGSEL_39
+  VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDC_76 VDDC_77 VDDC_78 VDDC_79
+  VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VPW_76
+  VPW_77 VPW_78 VPW_79 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[1] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCC[20]B BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[20]T BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[20][10] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[20][11] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[20][12] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[20][13] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[20][14] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[20][1] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[20][2] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[20][3] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[20][4] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[20][5] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[20][6] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[20][7] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[20][8] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[20][9] BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 DATAIN_40 DATAIN_41 GDL_40 GDL_41 NBIT_A_80 NBIT_A_81 NBIT_A_82
+  NBIT_A_83 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NWGSEL_40 NWGSEL_41
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDC_80 VDDC_81 VDDC_82 VDDC_83
+  VDDPE_80 VDDPE_81 VDDPE_82 VDDPE_83 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VPW_80
+  VPW_81 VPW_82 VPW_83 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[21]B BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[21]T BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[21][10] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[21][11] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[21][12] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[21][13] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[21][14] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[21][1] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[21][2] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[21][3] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[21][4] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[21][5] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[21][6] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[21][7] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[21][8] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[21][9] BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87 BIT_B_84 BIT_B_85 BIT_B_86
+  BIT_B_87 DATAIN_42 DATAIN_43 GDL_42 GDL_43 NBIT_A_84 NBIT_A_85 NBIT_A_86
+  NBIT_A_87 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87 NWGSEL_42 NWGSEL_43
+  VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VPW_84
+  VPW_85 VPW_86 VPW_87 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[22]B BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[22]T BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[22][10] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[22][11] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[22][12] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[22][13] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[22][14] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[22][1] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[22][2] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[22][3] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[22][4] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[22][5] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[22][6] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[22][7] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[22][8] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[22][9] BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 DATAIN_44 DATAIN_45 GDL_44 GDL_45 NBIT_A_88 NBIT_A_89 NBIT_A_90
+  NBIT_A_91 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NWGSEL_44 NWGSEL_45
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDC_88 VDDC_89 VDDC_90 VDDC_91
+  VDDPE_88 VDDPE_89 VDDPE_90 VDDPE_91 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VPW_88
+  VPW_89 VPW_90 VPW_91 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[23]B BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[23]T BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[23][10] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[23][11] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[23][12] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[23][13] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[23][14] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[23][1] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[23][2] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[23][3] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[23][4] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[23][5] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[23][6] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[23][7] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[23][8] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[23][9] BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95 BIT_B_92 BIT_B_93 BIT_B_94
+  BIT_B_95 DATAIN_46 DATAIN_47 GDL_46 GDL_47 NBIT_A_92 NBIT_A_93 NBIT_A_94
+  NBIT_A_95 NBIT_B_92 NBIT_B_93 NBIT_B_94 NBIT_B_95 NWGSEL_46 NWGSEL_47
+  VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDC_92 VDDC_93 VDDC_94 VDDC_95
+  VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VPW_92
+  VPW_93 VPW_94 VPW_95 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[24]B BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[24]T BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[24][10] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[24][11] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[24][12] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[24][13] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[24][14] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[24][1] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[24][2] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[24][3] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[24][4] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[24][5] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[24][6] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[24][7] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[24][8] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[24][9] BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 DATAIN_48 DATAIN_49 GDL_48 GDL_49 NBIT_A_96 NBIT_A_97 NBIT_A_98
+  NBIT_A_99 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NWGSEL_48 NWGSEL_49
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDC_96 VDDC_97 VDDC_98 VDDC_99
+  VDDPE_96 VDDPE_97 VDDPE_98 VDDPE_99 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VPW_96
+  VPW_97 VPW_98 VPW_99 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[25]B BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101 BIT_B_102
+  BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCC[25]T BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101 BIT_B_102
+  BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[25][10] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[25][11] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[25][12] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[25][13] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[25][14] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[25][1] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCC[25][2] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[25][3] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[25][4] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[25][5] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[25][6] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[25][7] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[25][8] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[25][9] BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 DATAIN_50 DATAIN_51 GDL_50 GDL_51 NBIT_A_100 NBIT_A_101
+  NBIT_A_102 NBIT_A_103 NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NWGSEL_50
+  NWGSEL_51 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDC_100 VDDC_101
+  VDDC_102 VDDC_103 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VNWC_100 VNWC_101
+  VNWC_102 VNWC_103 VPW_100 VPW_101 VPW_102 VPW_103 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[26]B BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105 BIT_B_106
+  BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_0 WL_A_1 WL_A_2
+  WL_A_3 WL_B_0 WL_B_1 WL_B_2 WL_B_3 SRAMdpw64d256CCARR4X4
XCC[26]T BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105 BIT_B_106
+  BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_60 WL_A_61
+  WL_A_62 WL_A_63 WL_B_60 WL_B_61 WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[26][10] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_40 WL_A_41
+  WL_A_42 WL_A_43 WL_B_40 WL_B_41 WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[26][11] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_44 WL_A_45
+  WL_A_46 WL_A_47 WL_B_44 WL_B_45 WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[26][12] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_48 WL_A_49
+  WL_A_50 WL_A_51 WL_B_48 WL_B_49 WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[26][13] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_52 WL_A_53
+  WL_A_54 WL_A_55 WL_B_52 WL_B_53 WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[26][14] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_56 WL_A_57
+  WL_A_58 WL_A_59 WL_B_56 WL_B_57 WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[26][1] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_4 WL_A_5 WL_A_6
+  WL_A_7 WL_B_4 WL_B_5 WL_B_6 WL_B_7 SRAMdpw64d256CCARR4X4
XCC[26][2] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[26][3] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[26][4] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[26][5] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[26][6] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[26][7] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[26][8] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[26][9] BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 DATAIN_52 DATAIN_53 GDL_52 GDL_53 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107 NWGSEL_52
+  NWGSEL_53 VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDC_104 VDDC_105
+  VDDC_106 VDDC_107 VDDPE_104 VDDPE_105 VDDPE_106 VDDPE_107 VNWC_104 VNWC_105
+  VNWC_106 VNWC_107 VPW_104 VPW_105 VPW_106 VPW_107 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[2] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_8 WL_A_9
+  WL_A_10 WL_A_11 WL_B_8 WL_B_9 WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[3] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_12 WL_A_13
+  WL_A_14 WL_A_15 WL_B_12 WL_B_13 WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[4] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_16 WL_A_17
+  WL_A_18 WL_A_19 WL_B_16 WL_B_17 WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[4]B BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[4]T BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[4][10] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[4][11] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[4][12] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[4][13] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[4][14] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[4][1] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[4][2] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[4][3] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[4][4] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[4][5] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[4][6] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[4][7] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[4][8] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[4][9] BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 DATAIN_8 DATAIN_9 GDL_8 GDL_9 NBIT_A_16 NBIT_A_17 NBIT_A_18
+  NBIT_A_19 NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NWGSEL_8 NWGSEL_9
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDC_16 VDDC_17 VDDC_18 VDDC_19
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VPW_16
+  VPW_17 VPW_18 VPW_19 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[5] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_20 WL_A_21
+  WL_A_22 WL_A_23 WL_B_20 WL_B_21 WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[5]B BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[5]T BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[5][10] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[5][11] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[5][12] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[5][13] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[5][14] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[5][1] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[5][2] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[5][3] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[5][4] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[5][5] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[5][6] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[5][7] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[5][8] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[5][9] BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23 BIT_B_20 BIT_B_21 BIT_B_22
+  BIT_B_23 DATAIN_10 DATAIN_11 GDL_10 GDL_11 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NWGSEL_10 NWGSEL_11
+  VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDC_20 VDDC_21 VDDC_22 VDDC_23
+  VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VPW_20
+  VPW_21 VPW_22 VPW_23 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[6] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_24 WL_A_25
+  WL_A_26 WL_A_27 WL_B_24 WL_B_25 WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[6]B BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[6]T BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[6][10] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[6][11] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[6][12] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[6][13] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[6][14] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[6][1] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[6][2] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[6][3] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[6][4] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[6][5] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[6][6] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[6][7] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[6][8] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[6][9] BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 DATAIN_12 DATAIN_13 GDL_12 GDL_13 NBIT_A_24 NBIT_A_25 NBIT_A_26
+  NBIT_A_27 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NWGSEL_12 NWGSEL_13
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDC_24 VDDC_25 VDDC_26 VDDC_27
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VPW_24
+  VPW_25 VPW_26 VPW_27 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[7] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_28 WL_A_29
+  WL_A_30 WL_A_31 WL_B_28 WL_B_29 WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[7]B BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[7]T BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[7][10] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[7][11] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[7][12] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[7][13] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[7][14] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[7][1] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[7][2] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[7][3] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[7][4] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[7][5] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[7][6] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[7][7] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[7][8] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[7][9] BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31 BIT_B_28 BIT_B_29 BIT_B_30
+  BIT_B_31 DATAIN_14 DATAIN_15 GDL_14 GDL_15 NBIT_A_28 NBIT_A_29 NBIT_A_30
+  NBIT_A_31 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31 NWGSEL_14 NWGSEL_15
+  VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDC_28 VDDC_29 VDDC_30 VDDC_31
+  VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VPW_28
+  VPW_29 VPW_30 VPW_31 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[8] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_32 WL_A_33
+  WL_A_34 WL_A_35 WL_B_32 WL_B_33 WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[8]B BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[8]T BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[8][10] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[8][11] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[8][12] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[8][13] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[8][14] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[8][1] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[8][2] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[8][3] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[8][4] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[8][5] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[8][6] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[8][7] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[8][8] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[8][9] BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 DATAIN_16 DATAIN_17 GDL_16 GDL_17 NBIT_A_32 NBIT_A_33 NBIT_A_34
+  NBIT_A_35 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NWGSEL_16 NWGSEL_17
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDC_32 VDDC_33 VDDC_34 VDDC_35
+  VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VPW_32
+  VPW_33 VPW_34 VPW_35 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[9] BIT_A_108 BIT_A_109 BIT_A_110 BIT_A_111 BIT_B_108 BIT_B_109 BIT_B_110
+  BIT_B_111 DATAIN_54 DATAIN_55 GDL_54 GDL_55 NBIT_A_108 NBIT_A_109
+  NBIT_A_110 NBIT_A_111 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NWGSEL_54
+  NWGSEL_55 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDC_108 VDDC_109
+  VDDC_110 VDDC_111 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111 VNWC_108 VNWC_109
+  VNWC_110 VNWC_111 VPW_108 VPW_109 VPW_110 VPW_111 VSSE WL_A_36 WL_A_37
+  WL_A_38 WL_A_39 WL_B_36 WL_B_37 WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
XCC[9]B BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_0 WL_A_1 WL_A_2 WL_A_3 WL_B_0 WL_B_1 WL_B_2
+  WL_B_3 SRAMdpw64d256CCARR4X4
XCC[9]T BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_60 WL_A_61 WL_A_62 WL_A_63 WL_B_60 WL_B_61
+  WL_B_62 WL_B_63 SRAMdpw64d256CCARR4X4
XCC[9][10] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_40 WL_A_41 WL_A_42 WL_A_43 WL_B_40 WL_B_41
+  WL_B_42 WL_B_43 SRAMdpw64d256CCARR4X4
XCC[9][11] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_44 WL_A_45 WL_A_46 WL_A_47 WL_B_44 WL_B_45
+  WL_B_46 WL_B_47 SRAMdpw64d256CCARR4X4
XCC[9][12] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_48 WL_A_49 WL_A_50 WL_A_51 WL_B_48 WL_B_49
+  WL_B_50 WL_B_51 SRAMdpw64d256CCARR4X4
XCC[9][13] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_52 WL_A_53 WL_A_54 WL_A_55 WL_B_52 WL_B_53
+  WL_B_54 WL_B_55 SRAMdpw64d256CCARR4X4
XCC[9][14] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_56 WL_A_57 WL_A_58 WL_A_59 WL_B_56 WL_B_57
+  WL_B_58 WL_B_59 SRAMdpw64d256CCARR4X4
XCC[9][1] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_4 WL_A_5 WL_A_6 WL_A_7 WL_B_4 WL_B_5 WL_B_6
+  WL_B_7 SRAMdpw64d256CCARR4X4
XCC[9][2] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_8 WL_A_9 WL_A_10 WL_A_11 WL_B_8 WL_B_9
+  WL_B_10 WL_B_11 SRAMdpw64d256CCARR4X4
XCC[9][3] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_12 WL_A_13 WL_A_14 WL_A_15 WL_B_12 WL_B_13
+  WL_B_14 WL_B_15 SRAMdpw64d256CCARR4X4
XCC[9][4] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_16 WL_A_17 WL_A_18 WL_A_19 WL_B_16 WL_B_17
+  WL_B_18 WL_B_19 SRAMdpw64d256CCARR4X4
XCC[9][5] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_20 WL_A_21 WL_A_22 WL_A_23 WL_B_20 WL_B_21
+  WL_B_22 WL_B_23 SRAMdpw64d256CCARR4X4
XCC[9][6] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_24 WL_A_25 WL_A_26 WL_A_27 WL_B_24 WL_B_25
+  WL_B_26 WL_B_27 SRAMdpw64d256CCARR4X4
XCC[9][7] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_28 WL_A_29 WL_A_30 WL_A_31 WL_B_28 WL_B_29
+  WL_B_30 WL_B_31 SRAMdpw64d256CCARR4X4
XCC[9][8] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_32 WL_A_33 WL_A_34 WL_A_35 WL_B_32 WL_B_33
+  WL_B_34 WL_B_35 SRAMdpw64d256CCARR4X4
XCC[9][9] BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39 BIT_B_36 BIT_B_37 BIT_B_38
+  BIT_B_39 DATAIN_18 DATAIN_19 GDL_18 GDL_19 NBIT_A_36 NBIT_A_37 NBIT_A_38
+  NBIT_A_39 NBIT_B_36 NBIT_B_37 NBIT_B_38 NBIT_B_39 NWGSEL_18 NWGSEL_19
+  VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDC_36 VDDC_37 VDDC_38 VDDC_39
+  VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VNWC_36 VNWC_37 VNWC_38 VNWC_39 VPW_36
+  VPW_37 VPW_38 VPW_39 VSSE WL_A_36 WL_A_37 WL_A_38 WL_A_39 WL_B_36 WL_B_37
+  WL_B_38 WL_B_39 SRAMdpw64d256CCARR4X4
.ENDS SRAMdpw64d256CARRAY_64_32R
****
.SUBCKT SRAMdpw64d256WLDRV2X8 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BNK_A BNK_B CLK_A CLK_B DBL_A DBL_B INXPDEC2_A
+  INXPDEC2_B INXPDEC3_A INXPDEC3_B LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A
+  NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A
+  NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDCE VDDPE VNWC
+  VNWP VPW VSSE WE_A WE_B WL_A[0] WL_A[1] WL_A[2] WL_A[3] WL_A[4] WL_A[5]
+  WL_A[6] WL_A[7] WL_B[0] WL_B[1] WL_B[2] WL_B[3] WL_B[4] WL_B[5] WL_B[6]
+  WL_B[7] WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256WLDRV2X8: 200 flat devices **
X_MIwl0_3.I15.MXNA1 IWL0_3.CLKA NWL_CLK_A VSSE VPW N11LL_CKT W=0.65U L=0.04U
X_MIwl0_3.I15.MXPA1 IWL0_3.CLKA NWL_CLK_A VDDPE VNWP P11LL_CKT W=1.94U L=0.04U
X_MIwl0_3.I2.MXNA1 IWL0_3.CLKB NWL_CLK_B VSSE VPW N11LL_CKT W=0.65U L=0.04U
X_MIwl0_3.I2.MXPA1 IWL0_3.CLKB NWL_CLK_B VDDPE VNWP P11LL_CKT W=1.94U L=0.04U
X_MIwl0_3.I41.MXNA1 IWL0_3.DEC23A_I INXPDEC3_A VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl0_3.I41.MXNA2 IWL0_3.DEC23A_I INXPDEC2_A VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl0_3.I41.MXPA1 IWL0_3.DEC23A_I INXPDEC3_A IWL0_3.I41.P1 VNWP P11LL_CKT
+  W=1.39U L=0.04U
X_MIwl0_3.I41.MXPA2 IWL0_3.I41.P1 INXPDEC2_A VDDPE VNWP P11LL_CKT W=1.39U
+  L=0.04U
X_MIwl0_3.I42.MXNA1 IWL0_3.DEC23B_I INXPDEC3_B VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl0_3.I42.MXNA2 IWL0_3.DEC23B_I INXPDEC2_B VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl0_3.I42.MXPA1 IWL0_3.DEC23B_I INXPDEC3_B IWL0_3.I42.P1 VNWP P11LL_CKT
+  W=1.39U L=0.04U
X_MIwl0_3.I42.MXPA2 IWL0_3.I42.P1 INXPDEC2_B VDDPE VNWP P11LL_CKT W=1.39U
+  L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXN0 IWL0_3.IWLA_0.IWL.NWL IWL0_3.IWLA_0.IWL.XP1
+  IWL0_3.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXN10 WL_A[3] IWL0_3.IWLA_0.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXN2 IWL0_3.IWLA_0.IWL.XP1 NXPDEC1_A[3] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXN3 IWL0_3.IWLA_0.IWL.XP1 RETA[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXP10 IWL0_3.IWLA_0.IWL.NWL IWL0_3.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXP11 IWL0_3.IWLA_0.IWL.NWL IWL0_3.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXP12 IWL0_3.IWLA_0.IWL.NWL IWL0_3.IWLA_0.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXP7 WL_A[3] IWL0_3.IWLA_0.IWL.NWL VDDCA2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwla_0.Iwl.MXP8 IWL0_3.IWLA_0.IWL.XP1 NXPDEC1_A[3] RET_SHR_DEC1A[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXN0 IWL0_3.IWLA_1.IWL.NWL IWL0_3.IWLA_1.IWL.XP1
+  IWL0_3.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXN10 WL_A[2] IWL0_3.IWLA_1.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXN2 IWL0_3.IWLA_1.IWL.XP1 NXPDEC1_A[2] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXN3 IWL0_3.IWLA_1.IWL.XP1 RETA[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXP10 IWL0_3.IWLA_1.IWL.NWL IWL0_3.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXP11 IWL0_3.IWLA_1.IWL.NWL IWL0_3.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXP12 IWL0_3.IWLA_1.IWL.NWL IWL0_3.IWLA_1.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXP7 WL_A[2] IWL0_3.IWLA_1.IWL.NWL VDDCA1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwla_1.Iwl.MXP8 IWL0_3.IWLA_1.IWL.XP1 NXPDEC1_A[2] RET_SHR_DEC1A[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXN0 IWL0_3.IWLA_2.IWL.NWL IWL0_3.IWLA_2.IWL.XP1
+  IWL0_3.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXN10 WL_A[1] IWL0_3.IWLA_2.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXN2 IWL0_3.IWLA_2.IWL.XP1 NXPDEC1_A[1] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXN3 IWL0_3.IWLA_2.IWL.XP1 RETA[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXP10 IWL0_3.IWLA_2.IWL.NWL IWL0_3.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXP11 IWL0_3.IWLA_2.IWL.NWL IWL0_3.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXP12 IWL0_3.IWLA_2.IWL.NWL IWL0_3.IWLA_2.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXP7 WL_A[1] IWL0_3.IWLA_2.IWL.NWL VDDCA2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwla_2.Iwl.MXP8 IWL0_3.IWLA_2.IWL.XP1 NXPDEC1_A[1] RET_SHR_DEC1A[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXN0 IWL0_3.IWLA_3.IWL.NWL IWL0_3.IWLA_3.IWL.XP1
+  IWL0_3.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXN10 WL_A[0] IWL0_3.IWLA_3.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXN2 IWL0_3.IWLA_3.IWL.XP1 NXPDEC1_A[0] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXN3 IWL0_3.IWLA_3.IWL.XP1 RETA[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXP10 IWL0_3.IWLA_3.IWL.NWL IWL0_3.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXP11 IWL0_3.IWLA_3.IWL.NWL IWL0_3.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXP12 IWL0_3.IWLA_3.IWL.NWL IWL0_3.IWLA_3.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXP7 WL_A[0] IWL0_3.IWLA_3.IWL.NWL VDDCA1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwla_3.Iwl.MXP8 IWL0_3.IWLA_3.IWL.XP1 NXPDEC1_A[0] RET_SHR_DEC1A[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXN0 IWL0_3.IWLB_0.IWL.NWL IWL0_3.IWLB_0.IWL.XP1
+  IWL0_3.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXN10 WL_B[3] IWL0_3.IWLB_0.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXN2 IWL0_3.IWLB_0.IWL.XP1 NXPDEC1_B[3] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXN3 IWL0_3.IWLB_0.IWL.XP1 RETB[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXP10 IWL0_3.IWLB_0.IWL.NWL IWL0_3.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXP11 IWL0_3.IWLB_0.IWL.NWL IWL0_3.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXP12 IWL0_3.IWLB_0.IWL.NWL IWL0_3.IWLB_0.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXP7 WL_B[3] IWL0_3.IWLB_0.IWL.NWL VDDCB2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwlb_0.Iwl.MXP8 IWL0_3.IWLB_0.IWL.XP1 NXPDEC1_B[3] RET_SHR_DEC1B[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXN0 IWL0_3.IWLB_1.IWL.NWL IWL0_3.IWLB_1.IWL.XP1
+  IWL0_3.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXN10 WL_B[2] IWL0_3.IWLB_1.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXN2 IWL0_3.IWLB_1.IWL.XP1 NXPDEC1_B[2] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXN3 IWL0_3.IWLB_1.IWL.XP1 RETB[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXP10 IWL0_3.IWLB_1.IWL.NWL IWL0_3.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXP11 IWL0_3.IWLB_1.IWL.NWL IWL0_3.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXP12 IWL0_3.IWLB_1.IWL.NWL IWL0_3.IWLB_1.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXP7 WL_B[2] IWL0_3.IWLB_1.IWL.NWL VDDCB1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwlb_1.Iwl.MXP8 IWL0_3.IWLB_1.IWL.XP1 NXPDEC1_B[2] RET_SHR_DEC1B[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXN0 IWL0_3.IWLB_2.IWL.NWL IWL0_3.IWLB_2.IWL.XP1
+  IWL0_3.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXN10 WL_B[1] IWL0_3.IWLB_2.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXN2 IWL0_3.IWLB_2.IWL.XP1 NXPDEC1_B[1] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXN3 IWL0_3.IWLB_2.IWL.XP1 RETB[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXP10 IWL0_3.IWLB_2.IWL.NWL IWL0_3.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXP11 IWL0_3.IWLB_2.IWL.NWL IWL0_3.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXP12 IWL0_3.IWLB_2.IWL.NWL IWL0_3.IWLB_2.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXP7 WL_B[1] IWL0_3.IWLB_2.IWL.NWL VDDCB2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwlb_2.Iwl.MXP8 IWL0_3.IWLB_2.IWL.XP1 NXPDEC1_B[1] RET_SHR_DEC1B[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXN0 IWL0_3.IWLB_3.IWL.NWL IWL0_3.IWLB_3.IWL.XP1
+  IWL0_3.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXN10 WL_B[0] IWL0_3.IWLB_3.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXN2 IWL0_3.IWLB_3.IWL.XP1 NXPDEC1_B[0] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXN3 IWL0_3.IWLB_3.IWL.XP1 RETB[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXP10 IWL0_3.IWLB_3.IWL.NWL IWL0_3.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXP11 IWL0_3.IWLB_3.IWL.NWL IWL0_3.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXP12 IWL0_3.IWLB_3.IWL.NWL IWL0_3.IWLB_3.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXP7 WL_B[0] IWL0_3.IWLB_3.IWL.NWL VDDCB1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl0_3.Iwlb_3.Iwl.MXP8 IWL0_3.IWLB_3.IWL.XP1 NXPDEC1_B[0] RET_SHR_DEC1B[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl0_3.MXN0 IWL0_3.NIB IWL0_3.CLKB VSSE VPW N11LL_CKT W=2.58U L=0.04U
X_MIwl0_3.MXN1 IWL0_3.N_CLKB IWL0_3.DEC23B_I IWL0_3.NIB VPW N11LL_CKT W=2.58U
+  L=0.04U
X_MIwl0_3.MXN2 IWL0_3.N_CLKA IWL0_3.DEC23A_I IWL0_3.NIA VPW N11LL_CKT W=2.58U
+  L=0.04U
X_MIwl0_3.MXN3 IWL0_3.NIA IWL0_3.CLKA VSSE VPW N11LL_CKT W=2.58U L=0.04U
X_MIwl7_4.I15.MXNA1 IWL7_4.CLKA NWL_CLK_A VSSE VPW N11LL_CKT W=0.65U L=0.04U
X_MIwl7_4.I15.MXPA1 IWL7_4.CLKA NWL_CLK_A VDDPE VNWP P11LL_CKT W=1.94U L=0.04U
X_MIwl7_4.I2.MXNA1 IWL7_4.CLKB NWL_CLK_B VSSE VPW N11LL_CKT W=0.65U L=0.04U
X_MIwl7_4.I2.MXPA1 IWL7_4.CLKB NWL_CLK_B VDDPE VNWP P11LL_CKT W=1.94U L=0.04U
X_MIwl7_4.I41.MXNA1 IWL7_4.DEC23A_I INXPDEC3_A VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl7_4.I41.MXNA2 IWL7_4.DEC23A_I INXPDEC2_A VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl7_4.I41.MXPA1 IWL7_4.DEC23A_I INXPDEC3_A IWL7_4.I41.P1 VNWP P11LL_CKT
+  W=1.39U L=0.04U
X_MIwl7_4.I41.MXPA2 IWL7_4.I41.P1 INXPDEC2_A VDDPE VNWP P11LL_CKT W=1.39U
+  L=0.04U
X_MIwl7_4.I42.MXNA1 IWL7_4.DEC23B_I INXPDEC3_B VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl7_4.I42.MXNA2 IWL7_4.DEC23B_I INXPDEC2_B VSSE VPW N11LL_CKT W=0.495U
+  L=0.04U
X_MIwl7_4.I42.MXPA1 IWL7_4.DEC23B_I INXPDEC3_B IWL7_4.I42.P1 VNWP P11LL_CKT
+  W=1.39U L=0.04U
X_MIwl7_4.I42.MXPA2 IWL7_4.I42.P1 INXPDEC2_B VDDPE VNWP P11LL_CKT W=1.39U
+  L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXN0 IWL7_4.IWLA_0.IWL.NWL IWL7_4.IWLA_0.IWL.XP1
+  IWL7_4.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXN10 WL_A[4] IWL7_4.IWLA_0.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXN2 IWL7_4.IWLA_0.IWL.XP1 NXPDEC1_A[4] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXN3 IWL7_4.IWLA_0.IWL.XP1 RETA[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXP10 IWL7_4.IWLA_0.IWL.NWL IWL7_4.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXP11 IWL7_4.IWLA_0.IWL.NWL IWL7_4.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXP12 IWL7_4.IWLA_0.IWL.NWL IWL7_4.IWLA_0.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXP7 WL_A[4] IWL7_4.IWLA_0.IWL.NWL VDDCA2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwla_0.Iwl.MXP8 IWL7_4.IWLA_0.IWL.XP1 NXPDEC1_A[4] RET_SHR_DEC1A[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXN0 IWL7_4.IWLA_1.IWL.NWL IWL7_4.IWLA_1.IWL.XP1
+  IWL7_4.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXN10 WL_A[5] IWL7_4.IWLA_1.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXN2 IWL7_4.IWLA_1.IWL.XP1 NXPDEC1_A[5] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXN3 IWL7_4.IWLA_1.IWL.XP1 RETA[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXP10 IWL7_4.IWLA_1.IWL.NWL IWL7_4.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXP11 IWL7_4.IWLA_1.IWL.NWL IWL7_4.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXP12 IWL7_4.IWLA_1.IWL.NWL IWL7_4.IWLA_1.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXP7 WL_A[5] IWL7_4.IWLA_1.IWL.NWL VDDCA1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwla_1.Iwl.MXP8 IWL7_4.IWLA_1.IWL.XP1 NXPDEC1_A[5] RET_SHR_DEC1A[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXN0 IWL7_4.IWLA_2.IWL.NWL IWL7_4.IWLA_2.IWL.XP1
+  IWL7_4.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXN10 WL_A[6] IWL7_4.IWLA_2.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXN2 IWL7_4.IWLA_2.IWL.XP1 NXPDEC1_A[6] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXN3 IWL7_4.IWLA_2.IWL.XP1 RETA[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXP10 IWL7_4.IWLA_2.IWL.NWL IWL7_4.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXP11 IWL7_4.IWLA_2.IWL.NWL IWL7_4.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXP12 IWL7_4.IWLA_2.IWL.NWL IWL7_4.IWLA_2.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXP7 WL_A[6] IWL7_4.IWLA_2.IWL.NWL VDDCA2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwla_2.Iwl.MXP8 IWL7_4.IWLA_2.IWL.XP1 NXPDEC1_A[6] RET_SHR_DEC1A[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXN0 IWL7_4.IWLA_3.IWL.NWL IWL7_4.IWLA_3.IWL.XP1
+  IWL7_4.N_CLKA VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXN10 WL_A[7] IWL7_4.IWLA_3.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXN2 IWL7_4.IWLA_3.IWL.XP1 NXPDEC1_A[7] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXN3 IWL7_4.IWLA_3.IWL.XP1 RETA[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXP10 IWL7_4.IWLA_3.IWL.NWL IWL7_4.CLKA VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXP11 IWL7_4.IWLA_3.IWL.NWL IWL7_4.DEC23A_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXP12 IWL7_4.IWLA_3.IWL.NWL IWL7_4.IWLA_3.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXP7 WL_A[7] IWL7_4.IWLA_3.IWL.NWL VDDCA1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwla_3.Iwl.MXP8 IWL7_4.IWLA_3.IWL.XP1 NXPDEC1_A[7] RET_SHR_DEC1A[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXN0 IWL7_4.IWLB_0.IWL.NWL IWL7_4.IWLB_0.IWL.XP1
+  IWL7_4.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXN10 WL_B[4] IWL7_4.IWLB_0.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXN2 IWL7_4.IWLB_0.IWL.XP1 NXPDEC1_B[4] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXN3 IWL7_4.IWLB_0.IWL.XP1 RETB[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXP10 IWL7_4.IWLB_0.IWL.NWL IWL7_4.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXP11 IWL7_4.IWLB_0.IWL.NWL IWL7_4.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXP12 IWL7_4.IWLB_0.IWL.NWL IWL7_4.IWLB_0.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXP7 WL_B[4] IWL7_4.IWLB_0.IWL.NWL VDDCB2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwlb_0.Iwl.MXP8 IWL7_4.IWLB_0.IWL.XP1 NXPDEC1_B[4] RET_SHR_DEC1B[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXN0 IWL7_4.IWLB_1.IWL.NWL IWL7_4.IWLB_1.IWL.XP1
+  IWL7_4.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXN10 WL_B[5] IWL7_4.IWLB_1.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXN2 IWL7_4.IWLB_1.IWL.XP1 NXPDEC1_B[5] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXN3 IWL7_4.IWLB_1.IWL.XP1 RETB[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXP10 IWL7_4.IWLB_1.IWL.NWL IWL7_4.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXP11 IWL7_4.IWLB_1.IWL.NWL IWL7_4.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXP12 IWL7_4.IWLB_1.IWL.NWL IWL7_4.IWLB_1.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXP7 WL_B[5] IWL7_4.IWLB_1.IWL.NWL VDDCB1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwlb_1.Iwl.MXP8 IWL7_4.IWLB_1.IWL.XP1 NXPDEC1_B[5] RET_SHR_DEC1B[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXN0 IWL7_4.IWLB_2.IWL.NWL IWL7_4.IWLB_2.IWL.XP1
+  IWL7_4.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXN10 WL_B[6] IWL7_4.IWLB_2.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXN2 IWL7_4.IWLB_2.IWL.XP1 NXPDEC1_B[6] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXN3 IWL7_4.IWLB_2.IWL.XP1 RETB[1] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXP10 IWL7_4.IWLB_2.IWL.NWL IWL7_4.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXP11 IWL7_4.IWLB_2.IWL.NWL IWL7_4.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXP12 IWL7_4.IWLB_2.IWL.NWL IWL7_4.IWLB_2.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXP7 WL_B[6] IWL7_4.IWLB_2.IWL.NWL VDDCB2 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwlb_2.Iwl.MXP8 IWL7_4.IWLB_2.IWL.XP1 NXPDEC1_B[6] RET_SHR_DEC1B[1]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXN0 IWL7_4.IWLB_3.IWL.NWL IWL7_4.IWLB_3.IWL.XP1
+  IWL7_4.N_CLKB VPW N11LL_CKT W=1.93U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXN10 WL_B[7] IWL7_4.IWLB_3.IWL.NWL VSSE VPW N11LL_CKT
+  W=3.4U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXN2 IWL7_4.IWLB_3.IWL.XP1 NXPDEC1_B[7] VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXN3 IWL7_4.IWLB_3.IWL.XP1 RETB[0] VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXP10 IWL7_4.IWLB_3.IWL.NWL IWL7_4.CLKB VDDCE VNWC
+  P11LL_CKT W=0.89U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXP11 IWL7_4.IWLB_3.IWL.NWL IWL7_4.DEC23B_I VDDCE VNWC
+  P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXP12 IWL7_4.IWLB_3.IWL.NWL IWL7_4.IWLB_3.IWL.XP1 VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXP7 WL_B[7] IWL7_4.IWLB_3.IWL.NWL VDDCB1 VNWC P11LL_CKT
+  W=8.52U L=0.04U
X_MIwl7_4.Iwlb_3.Iwl.MXP8 IWL7_4.IWLB_3.IWL.XP1 NXPDEC1_B[7] RET_SHR_DEC1B[0]
+  VNWC P11LL_CKT W=0.5U L=0.04U
X_MIwl7_4.MXN0 IWL7_4.NIB IWL7_4.CLKB VSSE VPW N11LL_CKT W=2.58U L=0.04U
X_MIwl7_4.MXN1 IWL7_4.N_CLKB IWL7_4.DEC23B_I IWL7_4.NIB VPW N11LL_CKT W=2.58U
+  L=0.04U
X_MIwl7_4.MXN2 IWL7_4.N_CLKA IWL7_4.DEC23A_I IWL7_4.NIA VPW N11LL_CKT W=2.58U
+  L=0.04U
X_MIwl7_4.MXN3 IWL7_4.NIA IWL7_4.CLKA VSSE VPW N11LL_CKT W=2.58U L=0.04U
X_MXNpga_0 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_1 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_10 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_11 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_2 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_3 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_4 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_5 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_6 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_7 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_8 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpga_9 DBL_A LOG0_DBL_A LOG0_DBL_A VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_0 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_1 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_10 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_11 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_2 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_3 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_4 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_5 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_6 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_7 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_8 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
X_MXNpgb_9 LOG0_DBL_B LOG0_DBL_B DBL_B VPW N11LL_CKT W=0.44U L=0.04U
.ENDS SRAMdpw64d256WLDRV2X8
****
.SUBCKT SRAMdpw64d256ROWCH64 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0]
+  ADDR_B[1] BNK_A BNK_B CLK_A CLK_B DBL_A DBL_B LOG0_DBL_A LOG0_DBL_B NACT
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3]
+  NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0]
+  NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5]
+  NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2]
+  NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7]
+  NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4]
+  NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1]
+  NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2]
+  NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0]
+  RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A RE_B VDDCA1 VDDCA2
+  VDDCB1 VDDCB2 VDDPE VNWC VPW WE_A WE_B WL_A[0]_0 WL_A[0]_1 WL_A[0]_2
+  WL_A[0]_3 WL_A[0]_4 WL_A[0]_5 WL_A[0]_6 WL_A[0]_7 WL_A[1]_0 WL_A[1]_1
+  WL_A[1]_2 WL_A[1]_3 WL_A[1]_4 WL_A[1]_5 WL_A[1]_6 WL_A[1]_7 WL_A[2]_0
+  WL_A[2]_1 WL_A[2]_2 WL_A[2]_3 WL_A[2]_4 WL_A[2]_5 WL_A[2]_6 WL_A[2]_7
+  WL_A[3]_0 WL_A[3]_1 WL_A[3]_2 WL_A[3]_3 WL_A[3]_4 WL_A[3]_5 WL_A[3]_6
+  WL_A[3]_7 WL_A[4]_0 WL_A[4]_1 WL_A[4]_2 WL_A[4]_3 WL_A[4]_4 WL_A[4]_5
+  WL_A[4]_6 WL_A[4]_7 WL_A[5]_0 WL_A[5]_1 WL_A[5]_2 WL_A[5]_3 WL_A[5]_4
+  WL_A[5]_5 WL_A[5]_6 WL_A[5]_7 WL_A[6]_0 WL_A[6]_1 WL_A[6]_2 WL_A[6]_3
+  WL_A[6]_4 WL_A[6]_5 WL_A[6]_6 WL_A[6]_7 WL_A[7]_0 WL_A[7]_1 WL_A[7]_2
+  WL_A[7]_3 WL_A[7]_4 WL_A[7]_5 WL_A[7]_6 WL_A[7]_7 WL_B[0]_0 WL_B[0]_1
+  WL_B[0]_2 WL_B[0]_3 WL_B[0]_4 WL_B[0]_5 WL_B[0]_6 WL_B[0]_7 WL_B[1]_0
+  WL_B[1]_1 WL_B[1]_2 WL_B[1]_3 WL_B[1]_4 WL_B[1]_5 WL_B[1]_6 WL_B[1]_7
+  WL_B[2]_0 WL_B[2]_1 WL_B[2]_2 WL_B[2]_3 WL_B[2]_4 WL_B[2]_5 WL_B[2]_6
+  WL_B[2]_7 WL_B[3]_0 WL_B[3]_1 WL_B[3]_2 WL_B[3]_3 WL_B[3]_4 WL_B[3]_5
+  WL_B[3]_6 WL_B[3]_7 WL_B[4]_0 WL_B[4]_1 WL_B[4]_2 WL_B[4]_3 WL_B[4]_4
+  WL_B[4]_5 WL_B[4]_6 WL_B[4]_7 WL_B[5]_0 WL_B[5]_1 WL_B[5]_2 WL_B[5]_3
+  WL_B[5]_4 WL_B[5]_5 WL_B[5]_6 WL_B[5]_7 WL_B[6]_0 WL_B[6]_1 WL_B[6]_2
+  WL_B[6]_3 WL_B[6]_4 WL_B[6]_5 WL_B[6]_6 WL_B[6]_7 WL_B[7]_0 WL_B[7]_1
+  WL_B[7]_2 WL_B[7]_3 WL_B[7]_4 WL_B[7]_5 WL_B[7]_6 WL_B[7]_7 WRA_MA WRB_MA
+  WTE_A WTE_B
** SRAMdpw64d256ROWCH64: 1600 flat devices **
XWLDRVMSB ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[7] NXPDEC2_B[7] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_7 WL_A[1]_7 WL_A[2]_7 WL_A[3]_7 WL_A[4]_7 WL_A[5]_7 WL_A[6]_7
+  WL_A[7]_7 WL_B[0]_7 WL_B[1]_7 WL_B[2]_7 WL_B[3]_7 WL_B[4]_7 WL_B[5]_7
+  WL_B[6]_7 WL_B[7]_7 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[0] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[0] NXPDEC2_B[0] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_0 WL_A[1]_0 WL_A[2]_0 WL_A[3]_0 WL_A[4]_0 WL_A[5]_0 WL_A[6]_0
+  WL_A[7]_0 WL_B[0]_0 WL_B[1]_0 WL_B[2]_0 WL_B[3]_0 WL_B[4]_0 WL_B[5]_0
+  WL_B[6]_0 WL_B[7]_0 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[1] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[1] NXPDEC2_B[1] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_1 WL_A[1]_1 WL_A[2]_1 WL_A[3]_1 WL_A[4]_1 WL_A[5]_1 WL_A[6]_1
+  WL_A[7]_1 WL_B[0]_1 WL_B[1]_1 WL_B[2]_1 WL_B[3]_1 WL_B[4]_1 WL_B[5]_1
+  WL_B[6]_1 WL_B[7]_1 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[2] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[2] NXPDEC2_B[2] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_2 WL_A[1]_2 WL_A[2]_2 WL_A[3]_2 WL_A[4]_2 WL_A[5]_2 WL_A[6]_2
+  WL_A[7]_2 WL_B[0]_2 WL_B[1]_2 WL_B[2]_2 WL_B[3]_2 WL_B[4]_2 WL_B[5]_2
+  WL_B[6]_2 WL_B[7]_2 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[3] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[3] NXPDEC2_B[3] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_3 WL_A[1]_3 WL_A[2]_3 WL_A[3]_3 WL_A[4]_3 WL_A[5]_3 WL_A[6]_3
+  WL_A[7]_3 WL_B[0]_3 WL_B[1]_3 WL_B[2]_3 WL_B[3]_3 WL_B[4]_3 WL_B[5]_3
+  WL_B[6]_3 WL_B[7]_3 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[4] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[4] NXPDEC2_B[4] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_4 WL_A[1]_4 WL_A[2]_4 WL_A[3]_4 WL_A[4]_4 WL_A[5]_4 WL_A[6]_4
+  WL_A[7]_4 WL_B[0]_4 WL_B[1]_4 WL_B[2]_4 WL_B[3]_4 WL_B[4]_4 WL_B[5]_4
+  WL_B[6]_4 WL_B[7]_4 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[5] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[5] NXPDEC2_B[5] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_5 WL_A[1]_5 WL_A[2]_5 WL_A[3]_5 WL_A[4]_5 WL_A[5]_5 WL_A[6]_5
+  WL_A[7]_5 WL_B[0]_5 WL_B[1]_5 WL_B[2]_5 WL_B[3]_5 WL_B[4]_5 WL_B[5]_5
+  WL_B[6]_5 WL_B[7]_5 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
XWLDRV[6] ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B NXPDEC2_A[6] NXPDEC2_B[6] NXPDEC3_A[0]
+  NXPDEC3_B[0] LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0]
+  NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5]
+  NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2]
+  NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7]
+  NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4]
+  NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1]
+  NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6]
+  NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3]
+  NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0]
+  RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1]
+  RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE VNWC VDDPE VPW VPW WE_A
+  WE_B WL_A[0]_6 WL_A[1]_6 WL_A[2]_6 WL_A[3]_6 WL_A[4]_6 WL_A[5]_6 WL_A[6]_6
+  WL_A[7]_6 WL_B[0]_6 WL_B[1]_6 WL_B[2]_6 WL_B[3]_6 WL_B[4]_6 WL_B[5]_6
+  WL_B[6]_6 WL_B[7]_6 WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256WLDRV2X8
.ENDS SRAMdpw64d256ROWCH64
****
.SUBCKT SRAMdpw64d256ARRAY_64_32_32 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_A_4 BIT_A_5 BIT_A_6
+  BIT_A_7 BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_A_12 BIT_A_13 BIT_A_14
+  BIT_A_15 BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_A_20 BIT_A_21 BIT_A_22
+  BIT_A_23 BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_A_28 BIT_A_29 BIT_A_30
+  BIT_A_31 BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_A_36 BIT_A_37 BIT_A_38
+  BIT_A_39 BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_A_44 BIT_A_45 BIT_A_46
+  BIT_A_47 BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_A_52 BIT_A_53 BIT_A_54
+  BIT_A_55 BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_A_60 BIT_A_61 BIT_A_62
+  BIT_A_63 BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_A_68 BIT_A_69 BIT_A_70
+  BIT_A_71 BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_A_76 BIT_A_77 BIT_A_78
+  BIT_A_79 BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_A_84 BIT_A_85 BIT_A_86
+  BIT_A_87 BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_A_92 BIT_A_93 BIT_A_94
+  BIT_A_95 BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_A_100 BIT_A_101 BIT_A_102
+  BIT_A_103 BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_A_108 BIT_A_109
+  BIT_A_110 BIT_A_111 BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_A_116
+  BIT_A_117 BIT_A_118 BIT_A_119 BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123
+  BIT_A_124 BIT_A_125 BIT_A_126 BIT_A_127 BIT_A_128 BIT_A_129 BIT_A_130
+  BIT_A_131 BIT_A_132 BIT_A_133 BIT_A_134 BIT_A_135 BIT_A_136 BIT_A_137
+  BIT_A_138 BIT_A_139 BIT_A_140 BIT_A_141 BIT_A_142 BIT_A_143 BIT_A_144
+  BIT_A_145 BIT_A_146 BIT_A_147 BIT_A_148 BIT_A_149 BIT_A_150 BIT_A_151
+  BIT_A_152 BIT_A_153 BIT_A_154 BIT_A_155 BIT_A_156 BIT_A_157 BIT_A_158
+  BIT_A_159 BIT_A_160 BIT_A_161 BIT_A_162 BIT_A_163 BIT_A_164 BIT_A_165
+  BIT_A_166 BIT_A_167 BIT_A_168 BIT_A_169 BIT_A_170 BIT_A_171 BIT_A_172
+  BIT_A_173 BIT_A_174 BIT_A_175 BIT_A_176 BIT_A_177 BIT_A_178 BIT_A_179
+  BIT_A_180 BIT_A_181 BIT_A_182 BIT_A_183 BIT_A_184 BIT_A_185 BIT_A_186
+  BIT_A_187 BIT_A_188 BIT_A_189 BIT_A_190 BIT_A_191 BIT_A_192 BIT_A_193
+  BIT_A_194 BIT_A_195 BIT_A_196 BIT_A_197 BIT_A_198 BIT_A_199 BIT_A_200
+  BIT_A_201 BIT_A_202 BIT_A_203 BIT_A_204 BIT_A_205 BIT_A_206 BIT_A_207
+  BIT_A_208 BIT_A_209 BIT_A_210 BIT_A_211 BIT_A_212 BIT_A_213 BIT_A_214
+  BIT_A_215 BIT_A_216 BIT_A_217 BIT_A_218 BIT_A_219 BIT_A_220 BIT_A_221
+  BIT_A_222 BIT_A_223 BIT_A_224 BIT_A_225 BIT_A_226 BIT_A_227 BIT_A_228
+  BIT_A_229 BIT_A_230 BIT_A_231 BIT_A_232 BIT_A_233 BIT_A_234 BIT_A_235
+  BIT_A_236 BIT_A_237 BIT_A_238 BIT_A_239 BIT_A_240 BIT_A_241 BIT_A_242
+  BIT_A_243 BIT_A_244 BIT_A_245 BIT_A_246 BIT_A_247 BIT_A_248 BIT_A_249
+  BIT_A_250 BIT_A_251 BIT_A_252 BIT_A_253 BIT_A_254 BIT_A_255 BIT_B_0 BIT_B_1
+  BIT_B_2 BIT_B_3 BIT_B_4 BIT_B_5 BIT_B_6 BIT_B_7 BIT_B_8 BIT_B_9 BIT_B_10
+  BIT_B_11 BIT_B_12 BIT_B_13 BIT_B_14 BIT_B_15 BIT_B_16 BIT_B_17 BIT_B_18
+  BIT_B_19 BIT_B_20 BIT_B_21 BIT_B_22 BIT_B_23 BIT_B_24 BIT_B_25 BIT_B_26
+  BIT_B_27 BIT_B_28 BIT_B_29 BIT_B_30 BIT_B_31 BIT_B_32 BIT_B_33 BIT_B_34
+  BIT_B_35 BIT_B_36 BIT_B_37 BIT_B_38 BIT_B_39 BIT_B_40 BIT_B_41 BIT_B_42
+  BIT_B_43 BIT_B_44 BIT_B_45 BIT_B_46 BIT_B_47 BIT_B_48 BIT_B_49 BIT_B_50
+  BIT_B_51 BIT_B_52 BIT_B_53 BIT_B_54 BIT_B_55 BIT_B_56 BIT_B_57 BIT_B_58
+  BIT_B_59 BIT_B_60 BIT_B_61 BIT_B_62 BIT_B_63 BIT_B_64 BIT_B_65 BIT_B_66
+  BIT_B_67 BIT_B_68 BIT_B_69 BIT_B_70 BIT_B_71 BIT_B_72 BIT_B_73 BIT_B_74
+  BIT_B_75 BIT_B_76 BIT_B_77 BIT_B_78 BIT_B_79 BIT_B_80 BIT_B_81 BIT_B_82
+  BIT_B_83 BIT_B_84 BIT_B_85 BIT_B_86 BIT_B_87 BIT_B_88 BIT_B_89 BIT_B_90
+  BIT_B_91 BIT_B_92 BIT_B_93 BIT_B_94 BIT_B_95 BIT_B_96 BIT_B_97 BIT_B_98
+  BIT_B_99 BIT_B_100 BIT_B_101 BIT_B_102 BIT_B_103 BIT_B_104 BIT_B_105
+  BIT_B_106 BIT_B_107 BIT_B_108 BIT_B_109 BIT_B_110 BIT_B_111 BIT_B_112
+  BIT_B_113 BIT_B_114 BIT_B_115 BIT_B_116 BIT_B_117 BIT_B_118 BIT_B_119
+  BIT_B_120 BIT_B_121 BIT_B_122 BIT_B_123 BIT_B_124 BIT_B_125 BIT_B_126
+  BIT_B_127 BIT_B_128 BIT_B_129 BIT_B_130 BIT_B_131 BIT_B_132 BIT_B_133
+  BIT_B_134 BIT_B_135 BIT_B_136 BIT_B_137 BIT_B_138 BIT_B_139 BIT_B_140
+  BIT_B_141 BIT_B_142 BIT_B_143 BIT_B_144 BIT_B_145 BIT_B_146 BIT_B_147
+  BIT_B_148 BIT_B_149 BIT_B_150 BIT_B_151 BIT_B_152 BIT_B_153 BIT_B_154
+  BIT_B_155 BIT_B_156 BIT_B_157 BIT_B_158 BIT_B_159 BIT_B_160 BIT_B_161
+  BIT_B_162 BIT_B_163 BIT_B_164 BIT_B_165 BIT_B_166 BIT_B_167 BIT_B_168
+  BIT_B_169 BIT_B_170 BIT_B_171 BIT_B_172 BIT_B_173 BIT_B_174 BIT_B_175
+  BIT_B_176 BIT_B_177 BIT_B_178 BIT_B_179 BIT_B_180 BIT_B_181 BIT_B_182
+  BIT_B_183 BIT_B_184 BIT_B_185 BIT_B_186 BIT_B_187 BIT_B_188 BIT_B_189
+  BIT_B_190 BIT_B_191 BIT_B_192 BIT_B_193 BIT_B_194 BIT_B_195 BIT_B_196
+  BIT_B_197 BIT_B_198 BIT_B_199 BIT_B_200 BIT_B_201 BIT_B_202 BIT_B_203
+  BIT_B_204 BIT_B_205 BIT_B_206 BIT_B_207 BIT_B_208 BIT_B_209 BIT_B_210
+  BIT_B_211 BIT_B_212 BIT_B_213 BIT_B_214 BIT_B_215 BIT_B_216 BIT_B_217
+  BIT_B_218 BIT_B_219 BIT_B_220 BIT_B_221 BIT_B_222 BIT_B_223 BIT_B_224
+  BIT_B_225 BIT_B_226 BIT_B_227 BIT_B_228 BIT_B_229 BIT_B_230 BIT_B_231
+  BIT_B_232 BIT_B_233 BIT_B_234 BIT_B_235 BIT_B_236 BIT_B_237 BIT_B_238
+  BIT_B_239 BIT_B_240 BIT_B_241 BIT_B_242 BIT_B_243 BIT_B_244 BIT_B_245
+  BIT_B_246 BIT_B_247 BIT_B_248 BIT_B_249 BIT_B_250 BIT_B_251 BIT_B_252
+  BIT_B_253 BIT_B_254 BIT_B_255 BNK_A BNK_B CLK_A CLK_B DATAIN_0 DATAIN_1
+  DATAIN_2 DATAIN_3 DATAIN_4 DATAIN_5 DATAIN_6 DATAIN_7 DATAIN_8 DATAIN_9
+  DATAIN_10 DATAIN_11 DATAIN_12 DATAIN_13 DATAIN_14 DATAIN_15 DATAIN_16
+  DATAIN_17 DATAIN_18 DATAIN_19 DATAIN_20 DATAIN_21 DATAIN_22 DATAIN_23
+  DATAIN_24 DATAIN_25 DATAIN_26 DATAIN_27 DATAIN_28 DATAIN_29 DATAIN_30
+  DATAIN_31 DATAIN_32 DATAIN_33 DATAIN_34 DATAIN_35 DATAIN_36 DATAIN_37
+  DATAIN_38 DATAIN_39 DATAIN_40 DATAIN_41 DATAIN_42 DATAIN_43 DATAIN_44
+  DATAIN_45 DATAIN_46 DATAIN_47 DATAIN_48 DATAIN_49 DATAIN_50 DATAIN_51
+  DATAIN_52 DATAIN_53 DATAIN_54 DATAIN_55 DATAIN_56 DATAIN_57 DATAIN_58
+  DATAIN_59 DATAIN_60 DATAIN_61 DATAIN_62 DATAIN_63 DATAIN_64 DATAIN_65
+  DATAIN_66 DATAIN_67 DATAIN_68 DATAIN_69 DATAIN_70 DATAIN_71 DATAIN_72
+  DATAIN_73 DATAIN_74 DATAIN_75 DATAIN_76 DATAIN_77 DATAIN_78 DATAIN_79
+  DATAIN_80 DATAIN_81 DATAIN_82 DATAIN_83 DATAIN_84 DATAIN_85 DATAIN_86
+  DATAIN_87 DATAIN_88 DATAIN_89 DATAIN_90 DATAIN_91 DATAIN_92 DATAIN_93
+  DATAIN_94 DATAIN_95 DATAIN_96 DATAIN_97 DATAIN_98 DATAIN_99 DATAIN_100
+  DATAIN_101 DATAIN_102 DATAIN_103 DATAIN_104 DATAIN_105 DATAIN_106
+  DATAIN_107 DATAIN_108 DATAIN_109 DATAIN_110 DATAIN_111 DATAIN_112
+  DATAIN_113 DATAIN_114 DATAIN_115 DATAIN_116 DATAIN_117 DATAIN_118
+  DATAIN_119 DATAIN_120 DATAIN_121 DATAIN_122 DATAIN_123 DATAIN_124
+  DATAIN_125 DATAIN_126 DATAIN_127 DBL_A DBL_B GDL_0 GDL_1 GDL_2 GDL_3 GDL_4
+  GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14 GDL_15
+  GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24 GDL_25
+  GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34 GDL_35
+  GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44 GDL_45
+  GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54 GDL_55
+  GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 GDL_64 GDL_65
+  GDL_66 GDL_67 GDL_68 GDL_69 GDL_70 GDL_71 GDL_72 GDL_73 GDL_74 GDL_75
+  GDL_76 GDL_77 GDL_78 GDL_79 GDL_80 GDL_81 GDL_82 GDL_83 GDL_84 GDL_85
+  GDL_86 GDL_87 GDL_88 GDL_89 GDL_90 GDL_91 GDL_92 GDL_93 GDL_94 GDL_95
+  GDL_96 GDL_97 GDL_98 GDL_99 GDL_100 GDL_101 GDL_102 GDL_103 GDL_104 GDL_105
+  GDL_106 GDL_107 GDL_108 GDL_109 GDL_110 GDL_111 GDL_112 GDL_113 GDL_114
+  GDL_115 GDL_116 GDL_117 GDL_118 GDL_119 GDL_120 GDL_121 GDL_122 GDL_123
+  GDL_124 GDL_125 GDL_126 GDL_127 LOG0_DBL_A LOG0_DBL_B NACT NBIT_A_0
+  NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_A_8
+  NBIT_A_9 NBIT_A_10 NBIT_A_11 NBIT_A_12 NBIT_A_13 NBIT_A_14 NBIT_A_15
+  NBIT_A_16 NBIT_A_17 NBIT_A_18 NBIT_A_19 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_A_24 NBIT_A_25 NBIT_A_26 NBIT_A_27 NBIT_A_28 NBIT_A_29
+  NBIT_A_30 NBIT_A_31 NBIT_A_32 NBIT_A_33 NBIT_A_34 NBIT_A_35 NBIT_A_36
+  NBIT_A_37 NBIT_A_38 NBIT_A_39 NBIT_A_40 NBIT_A_41 NBIT_A_42 NBIT_A_43
+  NBIT_A_44 NBIT_A_45 NBIT_A_46 NBIT_A_47 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_A_52 NBIT_A_53 NBIT_A_54 NBIT_A_55 NBIT_A_56 NBIT_A_57
+  NBIT_A_58 NBIT_A_59 NBIT_A_60 NBIT_A_61 NBIT_A_62 NBIT_A_63 NBIT_A_64
+  NBIT_A_65 NBIT_A_66 NBIT_A_67 NBIT_A_68 NBIT_A_69 NBIT_A_70 NBIT_A_71
+  NBIT_A_72 NBIT_A_73 NBIT_A_74 NBIT_A_75 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_A_80 NBIT_A_81 NBIT_A_82 NBIT_A_83 NBIT_A_84 NBIT_A_85
+  NBIT_A_86 NBIT_A_87 NBIT_A_88 NBIT_A_89 NBIT_A_90 NBIT_A_91 NBIT_A_92
+  NBIT_A_93 NBIT_A_94 NBIT_A_95 NBIT_A_96 NBIT_A_97 NBIT_A_98 NBIT_A_99
+  NBIT_A_100 NBIT_A_101 NBIT_A_102 NBIT_A_103 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_A_108 NBIT_A_109 NBIT_A_110 NBIT_A_111
+  NBIT_A_112 NBIT_A_113 NBIT_A_114 NBIT_A_115 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_A_120 NBIT_A_121 NBIT_A_122 NBIT_A_123
+  NBIT_A_124 NBIT_A_125 NBIT_A_126 NBIT_A_127 NBIT_A_128 NBIT_A_129
+  NBIT_A_130 NBIT_A_131 NBIT_A_132 NBIT_A_133 NBIT_A_134 NBIT_A_135
+  NBIT_A_136 NBIT_A_137 NBIT_A_138 NBIT_A_139 NBIT_A_140 NBIT_A_141
+  NBIT_A_142 NBIT_A_143 NBIT_A_144 NBIT_A_145 NBIT_A_146 NBIT_A_147
+  NBIT_A_148 NBIT_A_149 NBIT_A_150 NBIT_A_151 NBIT_A_152 NBIT_A_153
+  NBIT_A_154 NBIT_A_155 NBIT_A_156 NBIT_A_157 NBIT_A_158 NBIT_A_159
+  NBIT_A_160 NBIT_A_161 NBIT_A_162 NBIT_A_163 NBIT_A_164 NBIT_A_165
+  NBIT_A_166 NBIT_A_167 NBIT_A_168 NBIT_A_169 NBIT_A_170 NBIT_A_171
+  NBIT_A_172 NBIT_A_173 NBIT_A_174 NBIT_A_175 NBIT_A_176 NBIT_A_177
+  NBIT_A_178 NBIT_A_179 NBIT_A_180 NBIT_A_181 NBIT_A_182 NBIT_A_183
+  NBIT_A_184 NBIT_A_185 NBIT_A_186 NBIT_A_187 NBIT_A_188 NBIT_A_189
+  NBIT_A_190 NBIT_A_191 NBIT_A_192 NBIT_A_193 NBIT_A_194 NBIT_A_195
+  NBIT_A_196 NBIT_A_197 NBIT_A_198 NBIT_A_199 NBIT_A_200 NBIT_A_201
+  NBIT_A_202 NBIT_A_203 NBIT_A_204 NBIT_A_205 NBIT_A_206 NBIT_A_207
+  NBIT_A_208 NBIT_A_209 NBIT_A_210 NBIT_A_211 NBIT_A_212 NBIT_A_213
+  NBIT_A_214 NBIT_A_215 NBIT_A_216 NBIT_A_217 NBIT_A_218 NBIT_A_219
+  NBIT_A_220 NBIT_A_221 NBIT_A_222 NBIT_A_223 NBIT_A_224 NBIT_A_225
+  NBIT_A_226 NBIT_A_227 NBIT_A_228 NBIT_A_229 NBIT_A_230 NBIT_A_231
+  NBIT_A_232 NBIT_A_233 NBIT_A_234 NBIT_A_235 NBIT_A_236 NBIT_A_237
+  NBIT_A_238 NBIT_A_239 NBIT_A_240 NBIT_A_241 NBIT_A_242 NBIT_A_243
+  NBIT_A_244 NBIT_A_245 NBIT_A_246 NBIT_A_247 NBIT_A_248 NBIT_A_249
+  NBIT_A_250 NBIT_A_251 NBIT_A_252 NBIT_A_253 NBIT_A_254 NBIT_A_255 NBIT_B_0
+  NBIT_B_1 NBIT_B_2 NBIT_B_3 NBIT_B_4 NBIT_B_5 NBIT_B_6 NBIT_B_7 NBIT_B_8
+  NBIT_B_9 NBIT_B_10 NBIT_B_11 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15
+  NBIT_B_16 NBIT_B_17 NBIT_B_18 NBIT_B_19 NBIT_B_20 NBIT_B_21 NBIT_B_22
+  NBIT_B_23 NBIT_B_24 NBIT_B_25 NBIT_B_26 NBIT_B_27 NBIT_B_28 NBIT_B_29
+  NBIT_B_30 NBIT_B_31 NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NBIT_B_36
+  NBIT_B_37 NBIT_B_38 NBIT_B_39 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43
+  NBIT_B_44 NBIT_B_45 NBIT_B_46 NBIT_B_47 NBIT_B_48 NBIT_B_49 NBIT_B_50
+  NBIT_B_51 NBIT_B_52 NBIT_B_53 NBIT_B_54 NBIT_B_55 NBIT_B_56 NBIT_B_57
+  NBIT_B_58 NBIT_B_59 NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NBIT_B_64
+  NBIT_B_65 NBIT_B_66 NBIT_B_67 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71
+  NBIT_B_72 NBIT_B_73 NBIT_B_74 NBIT_B_75 NBIT_B_76 NBIT_B_77 NBIT_B_78
+  NBIT_B_79 NBIT_B_80 NBIT_B_81 NBIT_B_82 NBIT_B_83 NBIT_B_84 NBIT_B_85
+  NBIT_B_86 NBIT_B_87 NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NBIT_B_92
+  NBIT_B_93 NBIT_B_94 NBIT_B_95 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99
+  NBIT_B_100 NBIT_B_101 NBIT_B_102 NBIT_B_103 NBIT_B_104 NBIT_B_105
+  NBIT_B_106 NBIT_B_107 NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111
+  NBIT_B_112 NBIT_B_113 NBIT_B_114 NBIT_B_115 NBIT_B_116 NBIT_B_117
+  NBIT_B_118 NBIT_B_119 NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123
+  NBIT_B_124 NBIT_B_125 NBIT_B_126 NBIT_B_127 NBIT_B_128 NBIT_B_129
+  NBIT_B_130 NBIT_B_131 NBIT_B_132 NBIT_B_133 NBIT_B_134 NBIT_B_135
+  NBIT_B_136 NBIT_B_137 NBIT_B_138 NBIT_B_139 NBIT_B_140 NBIT_B_141
+  NBIT_B_142 NBIT_B_143 NBIT_B_144 NBIT_B_145 NBIT_B_146 NBIT_B_147
+  NBIT_B_148 NBIT_B_149 NBIT_B_150 NBIT_B_151 NBIT_B_152 NBIT_B_153
+  NBIT_B_154 NBIT_B_155 NBIT_B_156 NBIT_B_157 NBIT_B_158 NBIT_B_159
+  NBIT_B_160 NBIT_B_161 NBIT_B_162 NBIT_B_163 NBIT_B_164 NBIT_B_165
+  NBIT_B_166 NBIT_B_167 NBIT_B_168 NBIT_B_169 NBIT_B_170 NBIT_B_171
+  NBIT_B_172 NBIT_B_173 NBIT_B_174 NBIT_B_175 NBIT_B_176 NBIT_B_177
+  NBIT_B_178 NBIT_B_179 NBIT_B_180 NBIT_B_181 NBIT_B_182 NBIT_B_183
+  NBIT_B_184 NBIT_B_185 NBIT_B_186 NBIT_B_187 NBIT_B_188 NBIT_B_189
+  NBIT_B_190 NBIT_B_191 NBIT_B_192 NBIT_B_193 NBIT_B_194 NBIT_B_195
+  NBIT_B_196 NBIT_B_197 NBIT_B_198 NBIT_B_199 NBIT_B_200 NBIT_B_201
+  NBIT_B_202 NBIT_B_203 NBIT_B_204 NBIT_B_205 NBIT_B_206 NBIT_B_207
+  NBIT_B_208 NBIT_B_209 NBIT_B_210 NBIT_B_211 NBIT_B_212 NBIT_B_213
+  NBIT_B_214 NBIT_B_215 NBIT_B_216 NBIT_B_217 NBIT_B_218 NBIT_B_219
+  NBIT_B_220 NBIT_B_221 NBIT_B_222 NBIT_B_223 NBIT_B_224 NBIT_B_225
+  NBIT_B_226 NBIT_B_227 NBIT_B_228 NBIT_B_229 NBIT_B_230 NBIT_B_231
+  NBIT_B_232 NBIT_B_233 NBIT_B_234 NBIT_B_235 NBIT_B_236 NBIT_B_237
+  NBIT_B_238 NBIT_B_239 NBIT_B_240 NBIT_B_241 NBIT_B_242 NBIT_B_243
+  NBIT_B_244 NBIT_B_245 NBIT_B_246 NBIT_B_247 NBIT_B_248 NBIT_B_249
+  NBIT_B_250 NBIT_B_251 NBIT_B_252 NBIT_B_253 NBIT_B_254 NBIT_B_255
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWGSEL_0 NWGSEL_1 NWGSEL_2 NWGSEL_3 NWGSEL_4 NWGSEL_5 NWGSEL_6 NWGSEL_7
+  NWGSEL_8 NWGSEL_9 NWGSEL_10 NWGSEL_11 NWGSEL_12 NWGSEL_13 NWGSEL_14
+  NWGSEL_15 NWGSEL_16 NWGSEL_17 NWGSEL_18 NWGSEL_19 NWGSEL_20 NWGSEL_21
+  NWGSEL_22 NWGSEL_23 NWGSEL_24 NWGSEL_25 NWGSEL_26 NWGSEL_27 NWGSEL_28
+  NWGSEL_29 NWGSEL_30 NWGSEL_31 NWGSEL_32 NWGSEL_33 NWGSEL_34 NWGSEL_35
+  NWGSEL_36 NWGSEL_37 NWGSEL_38 NWGSEL_39 NWGSEL_40 NWGSEL_41 NWGSEL_42
+  NWGSEL_43 NWGSEL_44 NWGSEL_45 NWGSEL_46 NWGSEL_47 NWGSEL_48 NWGSEL_49
+  NWGSEL_50 NWGSEL_51 NWGSEL_52 NWGSEL_53 NWGSEL_54 NWGSEL_55 NWGSEL_56
+  NWGSEL_57 NWGSEL_58 NWGSEL_59 NWGSEL_60 NWGSEL_61 NWGSEL_62 NWGSEL_63
+  NWGSEL_64 NWGSEL_65 NWGSEL_66 NWGSEL_67 NWGSEL_68 NWGSEL_69 NWGSEL_70
+  NWGSEL_71 NWGSEL_72 NWGSEL_73 NWGSEL_74 NWGSEL_75 NWGSEL_76 NWGSEL_77
+  NWGSEL_78 NWGSEL_79 NWGSEL_80 NWGSEL_81 NWGSEL_82 NWGSEL_83 NWGSEL_84
+  NWGSEL_85 NWGSEL_86 NWGSEL_87 NWGSEL_88 NWGSEL_89 NWGSEL_90 NWGSEL_91
+  NWGSEL_92 NWGSEL_93 NWGSEL_94 NWGSEL_95 NWGSEL_96 NWGSEL_97 NWGSEL_98
+  NWGSEL_99 NWGSEL_100 NWGSEL_101 NWGSEL_102 NWGSEL_103 NWGSEL_104 NWGSEL_105
+  NWGSEL_106 NWGSEL_107 NWGSEL_108 NWGSEL_109 NWGSEL_110 NWGSEL_111
+  NWGSEL_112 NWGSEL_113 NWGSEL_114 NWGSEL_115 NWGSEL_116 NWGSEL_117
+  NWGSEL_118 NWGSEL_119 NWGSEL_120 NWGSEL_121 NWGSEL_122 NWGSEL_123
+  NWGSEL_124 NWGSEL_125 NWGSEL_126 NWGSEL_127 NWL_CLK_A NWL_CLK_B
+  NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDCE_0 VDDCE_1
+  VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10
+  VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18
+  VDDCE_19 VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26
+  VDDCE_27 VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33 VDDCE_34
+  VDDCE_35 VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDCE_40 VDDCE_41 VDDCE_42
+  VDDCE_43 VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDCE_48 VDDCE_49 VDDCE_50
+  VDDCE_51 VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55 VDDCE_56 VDDCE_57 VDDCE_58
+  VDDCE_59 VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63 VDDCE_64 VDDCE_65 VDDCE_66
+  VDDCE_67 VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71 VDDCE_72 VDDCE_73 VDDCE_74
+  VDDCE_75 VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79 VDDCE_80 VDDCE_81 VDDCE_82
+  VDDCE_83 VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87 VDDCE_88 VDDCE_89 VDDCE_90
+  VDDCE_91 VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95 VDDCE_96 VDDCE_97 VDDCE_98
+  VDDCE_99 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103 VDDCE_104 VDDCE_105
+  VDDCE_106 VDDCE_107 VDDCE_108 VDDCE_109 VDDCE_110 VDDCE_111 VDDCE_112
+  VDDCE_113 VDDCE_114 VDDCE_115 VDDCE_116 VDDCE_117 VDDCE_118 VDDCE_119
+  VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDCE_124 VDDCE_125 VDDCE_126
+  VDDCE_127 VDDCE_128 VDDCE_129 VDDCE_130 VDDCE_131 VDDCE_132 VDDCE_133
+  VDDCE_134 VDDCE_135 VDDCE_136 VDDCE_137 VDDCE_138 VDDCE_139 VDDCE_140
+  VDDCE_141 VDDCE_142 VDDCE_143 VDDCE_144 VDDCE_145 VDDCE_146 VDDCE_147
+  VDDCE_148 VDDCE_149 VDDCE_150 VDDCE_151 VDDCE_152 VDDCE_153 VDDCE_154
+  VDDCE_155 VDDCE_156 VDDCE_157 VDDCE_158 VDDCE_159 VDDCE_160 VDDCE_161
+  VDDCE_162 VDDCE_163 VDDCE_164 VDDCE_165 VDDCE_166 VDDCE_167 VDDCE_168
+  VDDCE_169 VDDCE_170 VDDCE_171 VDDCE_172 VDDCE_173 VDDCE_174 VDDCE_175
+  VDDCE_176 VDDCE_177 VDDCE_178 VDDCE_179 VDDCE_180 VDDCE_181 VDDCE_182
+  VDDCE_183 VDDCE_184 VDDCE_185 VDDCE_186 VDDCE_187 VDDCE_188 VDDCE_189
+  VDDCE_190 VDDCE_191 VDDCE_192 VDDCE_193 VDDCE_194 VDDCE_195 VDDCE_196
+  VDDCE_197 VDDCE_198 VDDCE_199 VDDCE_200 VDDCE_201 VDDCE_202 VDDCE_203
+  VDDCE_204 VDDCE_205 VDDCE_206 VDDCE_207 VDDCE_208 VDDCE_209 VDDCE_210
+  VDDCE_211 VDDCE_212 VDDCE_213 VDDCE_214 VDDCE_215 VDDCE_216 VDDCE_217
+  VDDCE_218 VDDCE_219 VDDCE_220 VDDCE_221 VDDCE_222 VDDCE_223 VDDCE_224
+  VDDCE_225 VDDCE_226 VDDCE_227 VDDCE_228 VDDCE_229 VDDCE_230 VDDCE_231
+  VDDCE_232 VDDCE_233 VDDCE_234 VDDCE_235 VDDCE_236 VDDCE_237 VDDCE_238
+  VDDCE_239 VDDCE_240 VDDCE_241 VDDCE_242 VDDCE_243 VDDCE_244 VDDCE_245
+  VDDCE_246 VDDCE_247 VDDCE_248 VDDCE_249 VDDCE_250 VDDCE_251 VDDCE_252
+  VDDCE_253 VDDCE_254 VDDCE_255 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24
+  VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33
+  VDDC_34 VDDC_35 VDDC_36 VDDC_37 VDDC_38 VDDC_39 VDDC_40 VDDC_41 VDDC_42
+  VDDC_43 VDDC_44 VDDC_45 VDDC_46 VDDC_47 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDC_52 VDDC_53 VDDC_54 VDDC_55 VDDC_56 VDDC_57 VDDC_58 VDDC_59 VDDC_60
+  VDDC_61 VDDC_62 VDDC_63 VDDC_64 VDDC_65 VDDC_66 VDDC_67 VDDC_68 VDDC_69
+  VDDC_70 VDDC_71 VDDC_72 VDDC_73 VDDC_74 VDDC_75 VDDC_76 VDDC_77 VDDC_78
+  VDDC_79 VDDC_80 VDDC_81 VDDC_82 VDDC_83 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDC_88 VDDC_89 VDDC_90 VDDC_91 VDDC_92 VDDC_93 VDDC_94 VDDC_95 VDDC_96
+  VDDC_97 VDDC_98 VDDC_99 VDDC_100 VDDC_101 VDDC_102 VDDC_103 VDDC_104
+  VDDC_105 VDDC_106 VDDC_107 VDDC_108 VDDC_109 VDDC_110 VDDC_111 VDDC_112
+  VDDC_113 VDDC_114 VDDC_115 VDDC_116 VDDC_117 VDDC_118 VDDC_119 VDDC_120
+  VDDC_121 VDDC_122 VDDC_123 VDDC_124 VDDC_125 VDDC_126 VDDC_127 VDDC_128
+  VDDC_129 VDDC_130 VDDC_131 VDDC_132 VDDC_133 VDDC_134 VDDC_135 VDDC_136
+  VDDC_137 VDDC_138 VDDC_139 VDDC_140 VDDC_141 VDDC_142 VDDC_143 VDDC_144
+  VDDC_145 VDDC_146 VDDC_147 VDDC_148 VDDC_149 VDDC_150 VDDC_151 VDDC_152
+  VDDC_153 VDDC_154 VDDC_155 VDDC_156 VDDC_157 VDDC_158 VDDC_159 VDDC_160
+  VDDC_161 VDDC_162 VDDC_163 VDDC_164 VDDC_165 VDDC_166 VDDC_167 VDDC_168
+  VDDC_169 VDDC_170 VDDC_171 VDDC_172 VDDC_173 VDDC_174 VDDC_175 VDDC_176
+  VDDC_177 VDDC_178 VDDC_179 VDDC_180 VDDC_181 VDDC_182 VDDC_183 VDDC_184
+  VDDC_185 VDDC_186 VDDC_187 VDDC_188 VDDC_189 VDDC_190 VDDC_191 VDDC_192
+  VDDC_193 VDDC_194 VDDC_195 VDDC_196 VDDC_197 VDDC_198 VDDC_199 VDDC_200
+  VDDC_201 VDDC_202 VDDC_203 VDDC_204 VDDC_205 VDDC_206 VDDC_207 VDDC_208
+  VDDC_209 VDDC_210 VDDC_211 VDDC_212 VDDC_213 VDDC_214 VDDC_215 VDDC_216
+  VDDC_217 VDDC_218 VDDC_219 VDDC_220 VDDC_221 VDDC_222 VDDC_223 VDDC_224
+  VDDC_225 VDDC_226 VDDC_227 VDDC_228 VDDC_229 VDDC_230 VDDC_231 VDDC_232
+  VDDC_233 VDDC_234 VDDC_235 VDDC_236 VDDC_237 VDDC_238 VDDC_239 VDDC_240
+  VDDC_241 VDDC_242 VDDC_243 VDDC_244 VDDC_245 VDDC_246 VDDC_247 VDDC_248
+  VDDC_249 VDDC_250 VDDC_251 VDDC_252 VDDC_253 VDDC_254 VDDC_255 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41
+  VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49
+  VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57
+  VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VDDPE_64 VDDPE_65
+  VDDPE_66 VDDPE_67 VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VDDPE_72 VDDPE_73
+  VDDPE_74 VDDPE_75 VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VDDPE_80 VDDPE_81
+  VDDPE_82 VDDPE_83 VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VDDPE_88 VDDPE_89
+  VDDPE_90 VDDPE_91 VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VDDPE_96 VDDPE_97
+  VDDPE_98 VDDPE_99 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VDDPE_104
+  VDDPE_105 VDDPE_106 VDDPE_107 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111
+  VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VDDPE_116 VDDPE_117 VDDPE_118
+  VDDPE_119 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VDDPE_124 VDDPE_125
+  VDDPE_126 VDDPE_127 VDDPE_128 VDDPE_129 VDDPE_130 VDDPE_131 VDDPE_132
+  VDDPE_133 VDDPE_134 VDDPE_135 VDDPE_136 VDDPE_137 VDDPE_138 VDDPE_139
+  VDDPE_140 VDDPE_141 VDDPE_142 VDDPE_143 VDDPE_144 VDDPE_145 VDDPE_146
+  VDDPE_147 VDDPE_148 VDDPE_149 VDDPE_150 VDDPE_151 VDDPE_152 VDDPE_153
+  VDDPE_154 VDDPE_155 VDDPE_156 VDDPE_157 VDDPE_158 VDDPE_159 VDDPE_160
+  VDDPE_161 VDDPE_162 VDDPE_163 VDDPE_164 VDDPE_165 VDDPE_166 VDDPE_167
+  VDDPE_168 VDDPE_169 VDDPE_170 VDDPE_171 VDDPE_172 VDDPE_173 VDDPE_174
+  VDDPE_175 VDDPE_176 VDDPE_177 VDDPE_178 VDDPE_179 VDDPE_180 VDDPE_181
+  VDDPE_182 VDDPE_183 VDDPE_184 VDDPE_185 VDDPE_186 VDDPE_187 VDDPE_188
+  VDDPE_189 VDDPE_190 VDDPE_191 VDDPE_192 VDDPE_193 VDDPE_194 VDDPE_195
+  VDDPE_196 VDDPE_197 VDDPE_198 VDDPE_199 VDDPE_200 VDDPE_201 VDDPE_202
+  VDDPE_203 VDDPE_204 VDDPE_205 VDDPE_206 VDDPE_207 VDDPE_208 VDDPE_209
+  VDDPE_210 VDDPE_211 VDDPE_212 VDDPE_213 VDDPE_214 VDDPE_215 VDDPE_216
+  VDDPE_217 VDDPE_218 VDDPE_219 VDDPE_220 VDDPE_221 VDDPE_222 VDDPE_223
+  VDDPE_224 VDDPE_225 VDDPE_226 VDDPE_227 VDDPE_228 VDDPE_229 VDDPE_230
+  VDDPE_231 VDDPE_232 VDDPE_233 VDDPE_234 VDDPE_235 VDDPE_236 VDDPE_237
+  VDDPE_238 VDDPE_239 VDDPE_240 VDDPE_241 VDDPE_242 VDDPE_243 VDDPE_244
+  VDDPE_245 VDDPE_246 VDDPE_247 VDDPE_248 VDDPE_249 VDDPE_250 VDDPE_251
+  VDDPE_252 VDDPE_253 VDDPE_254 VDDPE_255 VDDPE_256 VNWC_0 VNWC_1 VNWC_2
+  VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8 VNWC_9 VNWC_10 VNWC_11 VNWC_12
+  VNWC_13 VNWC_14 VNWC_15 VNWC_16 VNWC_17 VNWC_18 VNWC_19 VNWC_20 VNWC_21
+  VNWC_22 VNWC_23 VNWC_24 VNWC_25 VNWC_26 VNWC_27 VNWC_28 VNWC_29 VNWC_30
+  VNWC_31 VNWC_32 VNWC_33 VNWC_34 VNWC_35 VNWC_36 VNWC_37 VNWC_38 VNWC_39
+  VNWC_40 VNWC_41 VNWC_42 VNWC_43 VNWC_44 VNWC_45 VNWC_46 VNWC_47 VNWC_48
+  VNWC_49 VNWC_50 VNWC_51 VNWC_52 VNWC_53 VNWC_54 VNWC_55 VNWC_56 VNWC_57
+  VNWC_58 VNWC_59 VNWC_60 VNWC_61 VNWC_62 VNWC_63 VNWC_64 VNWC_65 VNWC_66
+  VNWC_67 VNWC_68 VNWC_69 VNWC_70 VNWC_71 VNWC_72 VNWC_73 VNWC_74 VNWC_75
+  VNWC_76 VNWC_77 VNWC_78 VNWC_79 VNWC_80 VNWC_81 VNWC_82 VNWC_83 VNWC_84
+  VNWC_85 VNWC_86 VNWC_87 VNWC_88 VNWC_89 VNWC_90 VNWC_91 VNWC_92 VNWC_93
+  VNWC_94 VNWC_95 VNWC_96 VNWC_97 VNWC_98 VNWC_99 VNWC_100 VNWC_101 VNWC_102
+  VNWC_103 VNWC_104 VNWC_105 VNWC_106 VNWC_107 VNWC_108 VNWC_109 VNWC_110
+  VNWC_111 VNWC_112 VNWC_113 VNWC_114 VNWC_115 VNWC_116 VNWC_117 VNWC_118
+  VNWC_119 VNWC_120 VNWC_121 VNWC_122 VNWC_123 VNWC_124 VNWC_125 VNWC_126
+  VNWC_127 VNWC_128 VNWC_129 VNWC_130 VNWC_131 VNWC_132 VNWC_133 VNWC_134
+  VNWC_135 VNWC_136 VNWC_137 VNWC_138 VNWC_139 VNWC_140 VNWC_141 VNWC_142
+  VNWC_143 VNWC_144 VNWC_145 VNWC_146 VNWC_147 VNWC_148 VNWC_149 VNWC_150
+  VNWC_151 VNWC_152 VNWC_153 VNWC_154 VNWC_155 VNWC_156 VNWC_157 VNWC_158
+  VNWC_159 VNWC_160 VNWC_161 VNWC_162 VNWC_163 VNWC_164 VNWC_165 VNWC_166
+  VNWC_167 VNWC_168 VNWC_169 VNWC_170 VNWC_171 VNWC_172 VNWC_173 VNWC_174
+  VNWC_175 VNWC_176 VNWC_177 VNWC_178 VNWC_179 VNWC_180 VNWC_181 VNWC_182
+  VNWC_183 VNWC_184 VNWC_185 VNWC_186 VNWC_187 VNWC_188 VNWC_189 VNWC_190
+  VNWC_191 VNWC_192 VNWC_193 VNWC_194 VNWC_195 VNWC_196 VNWC_197 VNWC_198
+  VNWC_199 VNWC_200 VNWC_201 VNWC_202 VNWC_203 VNWC_204 VNWC_205 VNWC_206
+  VNWC_207 VNWC_208 VNWC_209 VNWC_210 VNWC_211 VNWC_212 VNWC_213 VNWC_214
+  VNWC_215 VNWC_216 VNWC_217 VNWC_218 VNWC_219 VNWC_220 VNWC_221 VNWC_222
+  VNWC_223 VNWC_224 VNWC_225 VNWC_226 VNWC_227 VNWC_228 VNWC_229 VNWC_230
+  VNWC_231 VNWC_232 VNWC_233 VNWC_234 VNWC_235 VNWC_236 VNWC_237 VNWC_238
+  VNWC_239 VNWC_240 VNWC_241 VNWC_242 VNWC_243 VNWC_244 VNWC_245 VNWC_246
+  VNWC_247 VNWC_248 VNWC_249 VNWC_250 VNWC_251 VNWC_252 VNWC_253 VNWC_254
+  VNWC_255 VNWC_256 VNWC_257 VNWC_258 VNWP_0 VNWP_1 VNWP_2 VNWP_3 VPW_0 VPW_1
+  VPW_2 VPW_3 VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13
+  VPW_14 VPW_15 VPW_16 VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23
+  VPW_24 VPW_25 VPW_26 VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33
+  VPW_34 VPW_35 VPW_36 VPW_37 VPW_38 VPW_39 VPW_40 VPW_41 VPW_42 VPW_43
+  VPW_44 VPW_45 VPW_46 VPW_47 VPW_48 VPW_49 VPW_50 VPW_51 VPW_52 VPW_53
+  VPW_54 VPW_55 VPW_56 VPW_57 VPW_58 VPW_59 VPW_60 VPW_61 VPW_62 VPW_63
+  VPW_64 VPW_65 VPW_66 VPW_67 VPW_68 VPW_69 VPW_70 VPW_71 VPW_72 VPW_73
+  VPW_74 VPW_75 VPW_76 VPW_77 VPW_78 VPW_79 VPW_80 VPW_81 VPW_82 VPW_83
+  VPW_84 VPW_85 VPW_86 VPW_87 VPW_88 VPW_89 VPW_90 VPW_91 VPW_92 VPW_93
+  VPW_94 VPW_95 VPW_96 VPW_97 VPW_98 VPW_99 VPW_100 VPW_101 VPW_102 VPW_103
+  VPW_104 VPW_105 VPW_106 VPW_107 VPW_108 VPW_109 VPW_110 VPW_111 VPW_112
+  VPW_113 VPW_114 VPW_115 VPW_116 VPW_117 VPW_118 VPW_119 VPW_120 VPW_121
+  VPW_122 VPW_123 VPW_124 VPW_125 VPW_126 VPW_127 VPW_128 VPW_129 VPW_130
+  VPW_131 VPW_132 VPW_133 VPW_134 VPW_135 VPW_136 VPW_137 VPW_138 VPW_139
+  VPW_140 VPW_141 VPW_142 VPW_143 VPW_144 VPW_145 VPW_146 VPW_147 VPW_148
+  VPW_149 VPW_150 VPW_151 VPW_152 VPW_153 VPW_154 VPW_155 VPW_156 VPW_157
+  VPW_158 VPW_159 VPW_160 VPW_161 VPW_162 VPW_163 VPW_164 VPW_165 VPW_166
+  VPW_167 VPW_168 VPW_169 VPW_170 VPW_171 VPW_172 VPW_173 VPW_174 VPW_175
+  VPW_176 VPW_177 VPW_178 VPW_179 VPW_180 VPW_181 VPW_182 VPW_183 VPW_184
+  VPW_185 VPW_186 VPW_187 VPW_188 VPW_189 VPW_190 VPW_191 VPW_192 VPW_193
+  VPW_194 VPW_195 VPW_196 VPW_197 VPW_198 VPW_199 VPW_200 VPW_201 VPW_202
+  VPW_203 VPW_204 VPW_205 VPW_206 VPW_207 VPW_208 VPW_209 VPW_210 VPW_211
+  VPW_212 VPW_213 VPW_214 VPW_215 VPW_216 VPW_217 VPW_218 VPW_219 VPW_220
+  VPW_221 VPW_222 VPW_223 VPW_224 VPW_225 VPW_226 VPW_227 VPW_228 VPW_229
+  VPW_230 VPW_231 VPW_232 VPW_233 VPW_234 VPW_235 VPW_236 VPW_237 VPW_238
+  VPW_239 VPW_240 VPW_241 VPW_242 VPW_243 VPW_244 VPW_245 VPW_246 VPW_247
+  VPW_248 VPW_249 VPW_250 VPW_251 VPW_252 VPW_253 VPW_254 VPW_255 VPW_256
+  WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256ARRAY_64_32_32: 132672 flat devices **
XLCOREARRAY BIT_A_0 BIT_A_1 BIT_A_2 BIT_A_3 BIT_A_4 BIT_A_5 BIT_A_6 BIT_A_7
+  BIT_A_8 BIT_A_9 BIT_A_10 BIT_A_11 BIT_A_12 BIT_A_13 BIT_A_14 BIT_A_15
+  BIT_A_16 BIT_A_17 BIT_A_18 BIT_A_19 BIT_A_20 BIT_A_21 BIT_A_22 BIT_A_23
+  BIT_A_24 BIT_A_25 BIT_A_26 BIT_A_27 BIT_A_28 BIT_A_29 BIT_A_30 BIT_A_31
+  BIT_A_32 BIT_A_33 BIT_A_34 BIT_A_35 BIT_A_36 BIT_A_37 BIT_A_38 BIT_A_39
+  BIT_A_40 BIT_A_41 BIT_A_42 BIT_A_43 BIT_A_44 BIT_A_45 BIT_A_46 BIT_A_47
+  BIT_A_48 BIT_A_49 BIT_A_50 BIT_A_51 BIT_A_52 BIT_A_53 BIT_A_54 BIT_A_55
+  BIT_A_56 BIT_A_57 BIT_A_58 BIT_A_59 BIT_A_60 BIT_A_61 BIT_A_62 BIT_A_63
+  BIT_A_64 BIT_A_65 BIT_A_66 BIT_A_67 BIT_A_68 BIT_A_69 BIT_A_70 BIT_A_71
+  BIT_A_72 BIT_A_73 BIT_A_74 BIT_A_75 BIT_A_76 BIT_A_77 BIT_A_78 BIT_A_79
+  BIT_A_80 BIT_A_81 BIT_A_82 BIT_A_83 BIT_A_84 BIT_A_85 BIT_A_86 BIT_A_87
+  BIT_A_88 BIT_A_89 BIT_A_90 BIT_A_91 BIT_A_92 BIT_A_93 BIT_A_94 BIT_A_95
+  BIT_A_96 BIT_A_97 BIT_A_98 BIT_A_99 BIT_A_100 BIT_A_101 BIT_A_102 BIT_A_103
+  BIT_A_104 BIT_A_105 BIT_A_106 BIT_A_107 BIT_A_108 BIT_A_109 BIT_A_110
+  BIT_A_111 BIT_A_112 BIT_A_113 BIT_A_114 BIT_A_115 BIT_A_116 BIT_A_117
+  BIT_A_118 BIT_A_119 BIT_A_120 BIT_A_121 BIT_A_122 BIT_A_123 BIT_A_124
+  BIT_A_125 BIT_A_126 BIT_A_127 BIT_B_0 BIT_B_1 BIT_B_2 BIT_B_3 BIT_B_4
+  BIT_B_5 BIT_B_6 BIT_B_7 BIT_B_8 BIT_B_9 BIT_B_10 BIT_B_11 BIT_B_12 BIT_B_13
+  BIT_B_14 BIT_B_15 BIT_B_16 BIT_B_17 BIT_B_18 BIT_B_19 BIT_B_20 BIT_B_21
+  BIT_B_22 BIT_B_23 BIT_B_24 BIT_B_25 BIT_B_26 BIT_B_27 BIT_B_28 BIT_B_29
+  BIT_B_30 BIT_B_31 BIT_B_32 BIT_B_33 BIT_B_34 BIT_B_35 BIT_B_36 BIT_B_37
+  BIT_B_38 BIT_B_39 BIT_B_40 BIT_B_41 BIT_B_42 BIT_B_43 BIT_B_44 BIT_B_45
+  BIT_B_46 BIT_B_47 BIT_B_48 BIT_B_49 BIT_B_50 BIT_B_51 BIT_B_52 BIT_B_53
+  BIT_B_54 BIT_B_55 BIT_B_56 BIT_B_57 BIT_B_58 BIT_B_59 BIT_B_60 BIT_B_61
+  BIT_B_62 BIT_B_63 BIT_B_64 BIT_B_65 BIT_B_66 BIT_B_67 BIT_B_68 BIT_B_69
+  BIT_B_70 BIT_B_71 BIT_B_72 BIT_B_73 BIT_B_74 BIT_B_75 BIT_B_76 BIT_B_77
+  BIT_B_78 BIT_B_79 BIT_B_80 BIT_B_81 BIT_B_82 BIT_B_83 BIT_B_84 BIT_B_85
+  BIT_B_86 BIT_B_87 BIT_B_88 BIT_B_89 BIT_B_90 BIT_B_91 BIT_B_92 BIT_B_93
+  BIT_B_94 BIT_B_95 BIT_B_96 BIT_B_97 BIT_B_98 BIT_B_99 BIT_B_100 BIT_B_101
+  BIT_B_102 BIT_B_103 BIT_B_104 BIT_B_105 BIT_B_106 BIT_B_107 BIT_B_108
+  BIT_B_109 BIT_B_110 BIT_B_111 BIT_B_112 BIT_B_113 BIT_B_114 BIT_B_115
+  BIT_B_116 BIT_B_117 BIT_B_118 BIT_B_119 BIT_B_120 BIT_B_121 BIT_B_122
+  BIT_B_123 BIT_B_124 BIT_B_125 BIT_B_126 BIT_B_127 DATAIN_0 DATAIN_1
+  DATAIN_2 DATAIN_3 DATAIN_4 DATAIN_5 DATAIN_6 DATAIN_7 DATAIN_8 DATAIN_9
+  DATAIN_10 DATAIN_11 DATAIN_12 DATAIN_13 DATAIN_14 DATAIN_15 DATAIN_16
+  DATAIN_17 DATAIN_18 DATAIN_19 DATAIN_20 DATAIN_21 DATAIN_22 DATAIN_23
+  DATAIN_24 DATAIN_25 DATAIN_26 DATAIN_27 DATAIN_28 DATAIN_29 DATAIN_30
+  DATAIN_31 DATAIN_32 DATAIN_33 DATAIN_34 DATAIN_35 DATAIN_36 DATAIN_37
+  DATAIN_38 DATAIN_39 DATAIN_40 DATAIN_41 DATAIN_42 DATAIN_43 DATAIN_44
+  DATAIN_45 DATAIN_46 DATAIN_47 DATAIN_48 DATAIN_49 DATAIN_50 DATAIN_51
+  DATAIN_52 DATAIN_53 DATAIN_54 DATAIN_55 DATAIN_56 DATAIN_57 DATAIN_58
+  DATAIN_59 DATAIN_60 DATAIN_61 DATAIN_62 DATAIN_63 GDL_0 GDL_1 GDL_2 GDL_3
+  GDL_4 GDL_5 GDL_6 GDL_7 GDL_8 GDL_9 GDL_10 GDL_11 GDL_12 GDL_13 GDL_14
+  GDL_15 GDL_16 GDL_17 GDL_18 GDL_19 GDL_20 GDL_21 GDL_22 GDL_23 GDL_24
+  GDL_25 GDL_26 GDL_27 GDL_28 GDL_29 GDL_30 GDL_31 GDL_32 GDL_33 GDL_34
+  GDL_35 GDL_36 GDL_37 GDL_38 GDL_39 GDL_40 GDL_41 GDL_42 GDL_43 GDL_44
+  GDL_45 GDL_46 GDL_47 GDL_48 GDL_49 GDL_50 GDL_51 GDL_52 GDL_53 GDL_54
+  GDL_55 GDL_56 GDL_57 GDL_58 GDL_59 GDL_60 GDL_61 GDL_62 GDL_63 NBIT_A_0
+  NBIT_A_1 NBIT_A_2 NBIT_A_3 NBIT_A_4 NBIT_A_5 NBIT_A_6 NBIT_A_7 NBIT_A_8
+  NBIT_A_9 NBIT_A_10 NBIT_A_11 NBIT_A_12 NBIT_A_13 NBIT_A_14 NBIT_A_15
+  NBIT_A_16 NBIT_A_17 NBIT_A_18 NBIT_A_19 NBIT_A_20 NBIT_A_21 NBIT_A_22
+  NBIT_A_23 NBIT_A_24 NBIT_A_25 NBIT_A_26 NBIT_A_27 NBIT_A_28 NBIT_A_29
+  NBIT_A_30 NBIT_A_31 NBIT_A_32 NBIT_A_33 NBIT_A_34 NBIT_A_35 NBIT_A_36
+  NBIT_A_37 NBIT_A_38 NBIT_A_39 NBIT_A_40 NBIT_A_41 NBIT_A_42 NBIT_A_43
+  NBIT_A_44 NBIT_A_45 NBIT_A_46 NBIT_A_47 NBIT_A_48 NBIT_A_49 NBIT_A_50
+  NBIT_A_51 NBIT_A_52 NBIT_A_53 NBIT_A_54 NBIT_A_55 NBIT_A_56 NBIT_A_57
+  NBIT_A_58 NBIT_A_59 NBIT_A_60 NBIT_A_61 NBIT_A_62 NBIT_A_63 NBIT_A_64
+  NBIT_A_65 NBIT_A_66 NBIT_A_67 NBIT_A_68 NBIT_A_69 NBIT_A_70 NBIT_A_71
+  NBIT_A_72 NBIT_A_73 NBIT_A_74 NBIT_A_75 NBIT_A_76 NBIT_A_77 NBIT_A_78
+  NBIT_A_79 NBIT_A_80 NBIT_A_81 NBIT_A_82 NBIT_A_83 NBIT_A_84 NBIT_A_85
+  NBIT_A_86 NBIT_A_87 NBIT_A_88 NBIT_A_89 NBIT_A_90 NBIT_A_91 NBIT_A_92
+  NBIT_A_93 NBIT_A_94 NBIT_A_95 NBIT_A_96 NBIT_A_97 NBIT_A_98 NBIT_A_99
+  NBIT_A_100 NBIT_A_101 NBIT_A_102 NBIT_A_103 NBIT_A_104 NBIT_A_105
+  NBIT_A_106 NBIT_A_107 NBIT_A_108 NBIT_A_109 NBIT_A_110 NBIT_A_111
+  NBIT_A_112 NBIT_A_113 NBIT_A_114 NBIT_A_115 NBIT_A_116 NBIT_A_117
+  NBIT_A_118 NBIT_A_119 NBIT_A_120 NBIT_A_121 NBIT_A_122 NBIT_A_123
+  NBIT_A_124 NBIT_A_125 NBIT_A_126 NBIT_A_127 NBIT_B_0 NBIT_B_1 NBIT_B_2
+  NBIT_B_3 NBIT_B_4 NBIT_B_5 NBIT_B_6 NBIT_B_7 NBIT_B_8 NBIT_B_9 NBIT_B_10
+  NBIT_B_11 NBIT_B_12 NBIT_B_13 NBIT_B_14 NBIT_B_15 NBIT_B_16 NBIT_B_17
+  NBIT_B_18 NBIT_B_19 NBIT_B_20 NBIT_B_21 NBIT_B_22 NBIT_B_23 NBIT_B_24
+  NBIT_B_25 NBIT_B_26 NBIT_B_27 NBIT_B_28 NBIT_B_29 NBIT_B_30 NBIT_B_31
+  NBIT_B_32 NBIT_B_33 NBIT_B_34 NBIT_B_35 NBIT_B_36 NBIT_B_37 NBIT_B_38
+  NBIT_B_39 NBIT_B_40 NBIT_B_41 NBIT_B_42 NBIT_B_43 NBIT_B_44 NBIT_B_45
+  NBIT_B_46 NBIT_B_47 NBIT_B_48 NBIT_B_49 NBIT_B_50 NBIT_B_51 NBIT_B_52
+  NBIT_B_53 NBIT_B_54 NBIT_B_55 NBIT_B_56 NBIT_B_57 NBIT_B_58 NBIT_B_59
+  NBIT_B_60 NBIT_B_61 NBIT_B_62 NBIT_B_63 NBIT_B_64 NBIT_B_65 NBIT_B_66
+  NBIT_B_67 NBIT_B_68 NBIT_B_69 NBIT_B_70 NBIT_B_71 NBIT_B_72 NBIT_B_73
+  NBIT_B_74 NBIT_B_75 NBIT_B_76 NBIT_B_77 NBIT_B_78 NBIT_B_79 NBIT_B_80
+  NBIT_B_81 NBIT_B_82 NBIT_B_83 NBIT_B_84 NBIT_B_85 NBIT_B_86 NBIT_B_87
+  NBIT_B_88 NBIT_B_89 NBIT_B_90 NBIT_B_91 NBIT_B_92 NBIT_B_93 NBIT_B_94
+  NBIT_B_95 NBIT_B_96 NBIT_B_97 NBIT_B_98 NBIT_B_99 NBIT_B_100 NBIT_B_101
+  NBIT_B_102 NBIT_B_103 NBIT_B_104 NBIT_B_105 NBIT_B_106 NBIT_B_107
+  NBIT_B_108 NBIT_B_109 NBIT_B_110 NBIT_B_111 NBIT_B_112 NBIT_B_113
+  NBIT_B_114 NBIT_B_115 NBIT_B_116 NBIT_B_117 NBIT_B_118 NBIT_B_119
+  NBIT_B_120 NBIT_B_121 NBIT_B_122 NBIT_B_123 NBIT_B_124 NBIT_B_125
+  NBIT_B_126 NBIT_B_127 NWGSEL_0 NWGSEL_1 NWGSEL_2 NWGSEL_3 NWGSEL_4 NWGSEL_5
+  NWGSEL_6 NWGSEL_7 NWGSEL_8 NWGSEL_9 NWGSEL_10 NWGSEL_11 NWGSEL_12 NWGSEL_13
+  NWGSEL_14 NWGSEL_15 NWGSEL_16 NWGSEL_17 NWGSEL_18 NWGSEL_19 NWGSEL_20
+  NWGSEL_21 NWGSEL_22 NWGSEL_23 NWGSEL_24 NWGSEL_25 NWGSEL_26 NWGSEL_27
+  NWGSEL_28 NWGSEL_29 NWGSEL_30 NWGSEL_31 NWGSEL_32 NWGSEL_33 NWGSEL_34
+  NWGSEL_35 NWGSEL_36 NWGSEL_37 NWGSEL_38 NWGSEL_39 NWGSEL_40 NWGSEL_41
+  NWGSEL_42 NWGSEL_43 NWGSEL_44 NWGSEL_45 NWGSEL_46 NWGSEL_47 NWGSEL_48
+  NWGSEL_49 NWGSEL_50 NWGSEL_51 NWGSEL_52 NWGSEL_53 NWGSEL_54 NWGSEL_55
+  NWGSEL_56 NWGSEL_57 NWGSEL_58 NWGSEL_59 NWGSEL_60 NWGSEL_61 NWGSEL_62
+  NWGSEL_63 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7
+  VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63
+  VDDCE_64 VDDCE_65 VDDCE_66 VDDCE_67 VDDCE_68 VDDCE_69 VDDCE_70 VDDCE_71
+  VDDCE_72 VDDCE_73 VDDCE_74 VDDCE_75 VDDCE_76 VDDCE_77 VDDCE_78 VDDCE_79
+  VDDCE_80 VDDCE_81 VDDCE_82 VDDCE_83 VDDCE_84 VDDCE_85 VDDCE_86 VDDCE_87
+  VDDCE_88 VDDCE_89 VDDCE_90 VDDCE_91 VDDCE_92 VDDCE_93 VDDCE_94 VDDCE_95
+  VDDCE_96 VDDCE_97 VDDCE_98 VDDCE_99 VDDCE_100 VDDCE_101 VDDCE_102 VDDCE_103
+  VDDCE_104 VDDCE_105 VDDCE_106 VDDCE_107 VDDCE_108 VDDCE_109 VDDCE_110
+  VDDCE_111 VDDCE_112 VDDCE_113 VDDCE_114 VDDCE_115 VDDCE_116 VDDCE_117
+  VDDCE_118 VDDCE_119 VDDCE_120 VDDCE_121 VDDCE_122 VDDCE_123 VDDCE_124
+  VDDCE_125 VDDCE_126 VDDCE_127 VDDC_0 VDDC_1 VDDC_2 VDDC_3 VDDC_4 VDDC_5
+  VDDC_6 VDDC_7 VDDC_8 VDDC_9 VDDC_10 VDDC_11 VDDC_12 VDDC_13 VDDC_14 VDDC_15
+  VDDC_16 VDDC_17 VDDC_18 VDDC_19 VDDC_20 VDDC_21 VDDC_22 VDDC_23 VDDC_24
+  VDDC_25 VDDC_26 VDDC_27 VDDC_28 VDDC_29 VDDC_30 VDDC_31 VDDC_32 VDDC_33
+  VDDC_34 VDDC_35 VDDC_36 VDDC_37 VDDC_38 VDDC_39 VDDC_40 VDDC_41 VDDC_42
+  VDDC_43 VDDC_44 VDDC_45 VDDC_46 VDDC_47 VDDC_48 VDDC_49 VDDC_50 VDDC_51
+  VDDC_52 VDDC_53 VDDC_54 VDDC_55 VDDC_56 VDDC_57 VDDC_58 VDDC_59 VDDC_60
+  VDDC_61 VDDC_62 VDDC_63 VDDC_64 VDDC_65 VDDC_66 VDDC_67 VDDC_68 VDDC_69
+  VDDC_70 VDDC_71 VDDC_72 VDDC_73 VDDC_74 VDDC_75 VDDC_76 VDDC_77 VDDC_78
+  VDDC_79 VDDC_80 VDDC_81 VDDC_82 VDDC_83 VDDC_84 VDDC_85 VDDC_86 VDDC_87
+  VDDC_88 VDDC_89 VDDC_90 VDDC_91 VDDC_92 VDDC_93 VDDC_94 VDDC_95 VDDC_96
+  VDDC_97 VDDC_98 VDDC_99 VDDC_100 VDDC_101 VDDC_102 VDDC_103 VDDC_104
+  VDDC_105 VDDC_106 VDDC_107 VDDC_108 VDDC_109 VDDC_110 VDDC_111 VDDC_112
+  VDDC_113 VDDC_114 VDDC_115 VDDC_116 VDDC_117 VDDC_118 VDDC_119 VDDC_120
+  VDDC_121 VDDC_122 VDDC_123 VDDC_124 VDDC_125 VDDC_126 VDDC_127 VDDPE_0
+  VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9
+  VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17
+  VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25
+  VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33
+  VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41
+  VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49
+  VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57
+  VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VDDPE_64 VDDPE_65
+  VDDPE_66 VDDPE_67 VDDPE_68 VDDPE_69 VDDPE_70 VDDPE_71 VDDPE_72 VDDPE_73
+  VDDPE_74 VDDPE_75 VDDPE_76 VDDPE_77 VDDPE_78 VDDPE_79 VDDPE_80 VDDPE_81
+  VDDPE_82 VDDPE_83 VDDPE_84 VDDPE_85 VDDPE_86 VDDPE_87 VDDPE_88 VDDPE_89
+  VDDPE_90 VDDPE_91 VDDPE_92 VDDPE_93 VDDPE_94 VDDPE_95 VDDPE_96 VDDPE_97
+  VDDPE_98 VDDPE_99 VDDPE_100 VDDPE_101 VDDPE_102 VDDPE_103 VDDPE_104
+  VDDPE_105 VDDPE_106 VDDPE_107 VDDPE_108 VDDPE_109 VDDPE_110 VDDPE_111
+  VDDPE_112 VDDPE_113 VDDPE_114 VDDPE_115 VDDPE_116 VDDPE_117 VDDPE_118
+  VDDPE_119 VDDPE_120 VDDPE_121 VDDPE_122 VDDPE_123 VDDPE_124 VDDPE_125
+  VDDPE_126 VDDPE_127 VNWC_1 VNWC_2 VNWC_3 VNWC_4 VNWC_5 VNWC_6 VNWC_7 VNWC_8
+  VNWC_9 VNWC_10 VNWC_11 VNWC_12 VNWC_13 VNWC_14 VNWC_15 VNWC_16 VNWC_17
+  VNWC_18 VNWC_19 VNWC_20 VNWC_21 VNWC_22 VNWC_23 VNWC_24 VNWC_25 VNWC_26
+  VNWC_27 VNWC_28 VNWC_29 VNWC_30 VNWC_31 VNWC_32 VNWC_33 VNWC_34 VNWC_35
+  VNWC_36 VNWC_37 VNWC_38 VNWC_39 VNWC_40 VNWC_41 VNWC_42 VNWC_43 VNWC_44
+  VNWC_45 VNWC_46 VNWC_47 VNWC_48 VNWC_49 VNWC_50 VNWC_51 VNWC_52 VNWC_53
+  VNWC_54 VNWC_55 VNWC_56 VNWC_57 VNWC_58 VNWC_59 VNWC_60 VNWC_61 VNWC_62
+  VNWC_63 VNWC_64 VNWC_65 VNWC_66 VNWC_67 VNWC_68 VNWC_69 VNWC_70 VNWC_71
+  VNWC_72 VNWC_73 VNWC_74 VNWC_75 VNWC_76 VNWC_77 VNWC_78 VNWC_79 VNWC_80
+  VNWC_81 VNWC_82 VNWC_83 VNWC_84 VNWC_85 VNWC_86 VNWC_87 VNWC_88 VNWC_89
+  VNWC_90 VNWC_91 VNWC_92 VNWC_93 VNWC_94 VNWC_95 VNWC_96 VNWC_97 VNWC_98
+  VNWC_99 VNWC_100 VNWC_101 VNWC_102 VNWC_103 VNWC_104 VNWC_105 VNWC_106
+  VNWC_107 VNWC_108 VNWC_109 VNWC_110 VNWC_111 VNWC_112 VNWC_113 VNWC_114
+  VNWC_115 VNWC_116 VNWC_117 VNWC_118 VNWC_119 VNWC_120 VNWC_121 VNWC_122
+  VNWC_123 VNWC_124 VNWC_125 VNWC_126 VNWC_127 VNWC_128 VPW_1 VPW_2 VPW_3
+  VPW_4 VPW_5 VPW_6 VPW_7 VPW_8 VPW_9 VPW_10 VPW_11 VPW_12 VPW_13 VPW_14
+  VPW_15 VPW_16 VPW_17 VPW_18 VPW_19 VPW_20 VPW_21 VPW_22 VPW_23 VPW_24
+  VPW_25 VPW_26 VPW_27 VPW_28 VPW_29 VPW_30 VPW_31 VPW_32 VPW_33 VPW_34
+  VPW_35 VPW_36 VPW_37 VPW_38 VPW_39 VPW_40 VPW_41 VPW_42 VPW_43 VPW_44
+  VPW_45 VPW_46 VPW_47 VPW_48 VPW_49 VPW_50 VPW_51 VPW_52 VPW_53 VPW_54
+  VPW_55 VPW_56 VPW_57 VPW_58 VPW_59 VPW_60 VPW_61 VPW_62 VPW_63 VPW_64
+  VPW_65 VPW_66 VPW_67 VPW_68 VPW_69 VPW_70 VPW_71 VPW_72 VPW_73 VPW_74
+  VPW_75 VPW_76 VPW_77 VPW_78 VPW_79 VPW_80 VPW_81 VPW_82 VPW_83 VPW_84
+  VPW_85 VPW_86 VPW_87 VPW_88 VPW_89 VPW_90 VPW_91 VPW_92 VPW_93 VPW_94
+  VPW_95 VPW_96 VPW_97 VPW_98 VPW_99 VPW_100 VPW_101 VPW_102 VPW_103 VPW_104
+  VPW_105 VPW_106 VPW_107 VPW_108 VPW_109 VPW_110 VPW_111 VPW_112 VPW_113
+  VPW_114 VPW_115 VPW_116 VPW_117 VPW_118 VPW_119 VPW_120 VPW_121 VPW_122
+  VPW_123 VPW_124 VPW_125 VPW_126 VPW_127 VPW_128 VPW_0 WL_A[0]_0 WL_A[1]_0
+  WL_A[2]_0 WL_A[3]_0 WL_A[0]_1 WL_A[1]_1 WL_A[2]_1 WL_A[3]_1 WL_A[0]_2
+  WL_A[1]_2 WL_A[2]_2 WL_A[3]_2 WL_A[0]_3 WL_A[1]_3 WL_A[2]_3 WL_A[3]_3
+  WL_A[0]_4 WL_A[1]_4 WL_A[2]_4 WL_A[3]_4 WL_A[0]_5 WL_A[1]_5 WL_A[2]_5
+  WL_A[3]_5 WL_A[0]_6 WL_A[1]_6 WL_A[2]_6 WL_A[3]_6 WL_A[0]_7 WL_A[1]_7
+  WL_A[2]_7 WL_A[3]_7 WL_A[0]_8 WL_A[1]_8 WL_A[2]_8 WL_A[3]_8 WL_A[0]_9
+  WL_A[1]_9 WL_A[2]_9 WL_A[3]_9 WL_A[0]_10 WL_A[1]_10 WL_A[2]_10 WL_A[3]_10
+  WL_A[0]_11 WL_A[1]_11 WL_A[2]_11 WL_A[3]_11 WL_A[0]_12 WL_A[1]_12
+  WL_A[2]_12 WL_A[3]_12 WL_A[0]_13 WL_A[1]_13 WL_A[2]_13 WL_A[3]_13
+  WL_A[0]_14 WL_A[1]_14 WL_A[2]_14 WL_A[3]_14 WL_A[0]_15 WL_A[1]_15
+  WL_A[2]_15 WL_A[3]_15 WL_B[0]_0 WL_B[1]_0 WL_B[2]_0 WL_B[3]_0 WL_B[0]_1
+  WL_B[1]_1 WL_B[2]_1 WL_B[3]_1 WL_B[0]_2 WL_B[1]_2 WL_B[2]_2 WL_B[3]_2
+  WL_B[0]_3 WL_B[1]_3 WL_B[2]_3 WL_B[3]_3 WL_B[0]_4 WL_B[1]_4 WL_B[2]_4
+  WL_B[3]_4 WL_B[0]_5 WL_B[1]_5 WL_B[2]_5 WL_B[3]_5 WL_B[0]_6 WL_B[1]_6
+  WL_B[2]_6 WL_B[3]_6 WL_B[0]_7 WL_B[1]_7 WL_B[2]_7 WL_B[3]_7 WL_B[0]_8
+  WL_B[1]_8 WL_B[2]_8 WL_B[3]_8 WL_B[0]_9 WL_B[1]_9 WL_B[2]_9 WL_B[3]_9
+  WL_B[0]_10 WL_B[1]_10 WL_B[2]_10 WL_B[3]_10 WL_B[0]_11 WL_B[1]_11
+  WL_B[2]_11 WL_B[3]_11 WL_B[0]_12 WL_B[1]_12 WL_B[2]_12 WL_B[3]_12
+  WL_B[0]_13 WL_B[1]_13 WL_B[2]_13 WL_B[3]_13 WL_B[0]_14 WL_B[1]_14
+  WL_B[2]_14 WL_B[3]_14 WL_B[0]_15 WL_B[1]_15 WL_B[2]_15 WL_B[3]_15
+  SRAMdpw64d256CARRAY_64_32L
XRCOREARRAY BIT_A_255 BIT_A_254 BIT_A_253 BIT_A_252 BIT_A_251 BIT_A_250
+  BIT_A_249 BIT_A_248 BIT_A_247 BIT_A_246 BIT_A_245 BIT_A_244 BIT_A_243
+  BIT_A_242 BIT_A_241 BIT_A_240 BIT_A_239 BIT_A_238 BIT_A_237 BIT_A_236
+  BIT_A_235 BIT_A_234 BIT_A_233 BIT_A_232 BIT_A_231 BIT_A_230 BIT_A_229
+  BIT_A_228 BIT_A_227 BIT_A_226 BIT_A_225 BIT_A_224 BIT_A_223 BIT_A_222
+  BIT_A_221 BIT_A_220 BIT_A_219 BIT_A_218 BIT_A_217 BIT_A_216 BIT_A_215
+  BIT_A_214 BIT_A_213 BIT_A_212 BIT_A_211 BIT_A_210 BIT_A_209 BIT_A_208
+  BIT_A_207 BIT_A_206 BIT_A_205 BIT_A_204 BIT_A_203 BIT_A_202 BIT_A_201
+  BIT_A_200 BIT_A_199 BIT_A_198 BIT_A_197 BIT_A_196 BIT_A_195 BIT_A_194
+  BIT_A_193 BIT_A_192 BIT_A_191 BIT_A_190 BIT_A_189 BIT_A_188 BIT_A_187
+  BIT_A_186 BIT_A_185 BIT_A_184 BIT_A_183 BIT_A_182 BIT_A_181 BIT_A_180
+  BIT_A_179 BIT_A_178 BIT_A_177 BIT_A_176 BIT_A_175 BIT_A_174 BIT_A_173
+  BIT_A_172 BIT_A_171 BIT_A_170 BIT_A_169 BIT_A_168 BIT_A_167 BIT_A_166
+  BIT_A_165 BIT_A_164 BIT_A_163 BIT_A_162 BIT_A_161 BIT_A_160 BIT_A_159
+  BIT_A_158 BIT_A_157 BIT_A_156 BIT_A_155 BIT_A_154 BIT_A_153 BIT_A_152
+  BIT_A_151 BIT_A_150 BIT_A_149 BIT_A_148 BIT_A_147 BIT_A_146 BIT_A_145
+  BIT_A_144 BIT_A_143 BIT_A_142 BIT_A_141 BIT_A_140 BIT_A_139 BIT_A_138
+  BIT_A_137 BIT_A_136 BIT_A_135 BIT_A_134 BIT_A_133 BIT_A_132 BIT_A_131
+  BIT_A_130 BIT_A_129 BIT_A_128 BIT_B_255 BIT_B_254 BIT_B_253 BIT_B_252
+  BIT_B_251 BIT_B_250 BIT_B_249 BIT_B_248 BIT_B_247 BIT_B_246 BIT_B_245
+  BIT_B_244 BIT_B_243 BIT_B_242 BIT_B_241 BIT_B_240 BIT_B_239 BIT_B_238
+  BIT_B_237 BIT_B_236 BIT_B_235 BIT_B_234 BIT_B_233 BIT_B_232 BIT_B_231
+  BIT_B_230 BIT_B_229 BIT_B_228 BIT_B_227 BIT_B_226 BIT_B_225 BIT_B_224
+  BIT_B_223 BIT_B_222 BIT_B_221 BIT_B_220 BIT_B_219 BIT_B_218 BIT_B_217
+  BIT_B_216 BIT_B_215 BIT_B_214 BIT_B_213 BIT_B_212 BIT_B_211 BIT_B_210
+  BIT_B_209 BIT_B_208 BIT_B_207 BIT_B_206 BIT_B_205 BIT_B_204 BIT_B_203
+  BIT_B_202 BIT_B_201 BIT_B_200 BIT_B_199 BIT_B_198 BIT_B_197 BIT_B_196
+  BIT_B_195 BIT_B_194 BIT_B_193 BIT_B_192 BIT_B_191 BIT_B_190 BIT_B_189
+  BIT_B_188 BIT_B_187 BIT_B_186 BIT_B_185 BIT_B_184 BIT_B_183 BIT_B_182
+  BIT_B_181 BIT_B_180 BIT_B_179 BIT_B_178 BIT_B_177 BIT_B_176 BIT_B_175
+  BIT_B_174 BIT_B_173 BIT_B_172 BIT_B_171 BIT_B_170 BIT_B_169 BIT_B_168
+  BIT_B_167 BIT_B_166 BIT_B_165 BIT_B_164 BIT_B_163 BIT_B_162 BIT_B_161
+  BIT_B_160 BIT_B_159 BIT_B_158 BIT_B_157 BIT_B_156 BIT_B_155 BIT_B_154
+  BIT_B_153 BIT_B_152 BIT_B_151 BIT_B_150 BIT_B_149 BIT_B_148 BIT_B_147
+  BIT_B_146 BIT_B_145 BIT_B_144 BIT_B_143 BIT_B_142 BIT_B_141 BIT_B_140
+  BIT_B_139 BIT_B_138 BIT_B_137 BIT_B_136 BIT_B_135 BIT_B_134 BIT_B_133
+  BIT_B_132 BIT_B_131 BIT_B_130 BIT_B_129 BIT_B_128 DATAIN_127 DATAIN_126
+  DATAIN_125 DATAIN_124 DATAIN_123 DATAIN_122 DATAIN_121 DATAIN_120
+  DATAIN_119 DATAIN_118 DATAIN_117 DATAIN_116 DATAIN_115 DATAIN_114
+  DATAIN_113 DATAIN_112 DATAIN_111 DATAIN_110 DATAIN_109 DATAIN_108
+  DATAIN_107 DATAIN_106 DATAIN_105 DATAIN_104 DATAIN_103 DATAIN_102
+  DATAIN_101 DATAIN_100 DATAIN_99 DATAIN_98 DATAIN_97 DATAIN_96 DATAIN_95
+  DATAIN_94 DATAIN_93 DATAIN_92 DATAIN_91 DATAIN_90 DATAIN_89 DATAIN_88
+  DATAIN_87 DATAIN_86 DATAIN_85 DATAIN_84 DATAIN_83 DATAIN_82 DATAIN_81
+  DATAIN_80 DATAIN_79 DATAIN_78 DATAIN_77 DATAIN_76 DATAIN_75 DATAIN_74
+  DATAIN_73 DATAIN_72 DATAIN_71 DATAIN_70 DATAIN_69 DATAIN_68 DATAIN_67
+  DATAIN_66 DATAIN_65 DATAIN_64 GDL_127 GDL_126 GDL_125 GDL_124 GDL_123
+  GDL_122 GDL_121 GDL_120 GDL_119 GDL_118 GDL_117 GDL_116 GDL_115 GDL_114
+  GDL_113 GDL_112 GDL_111 GDL_110 GDL_109 GDL_108 GDL_107 GDL_106 GDL_105
+  GDL_104 GDL_103 GDL_102 GDL_101 GDL_100 GDL_99 GDL_98 GDL_97 GDL_96 GDL_95
+  GDL_94 GDL_93 GDL_92 GDL_91 GDL_90 GDL_89 GDL_88 GDL_87 GDL_86 GDL_85
+  GDL_84 GDL_83 GDL_82 GDL_81 GDL_80 GDL_79 GDL_78 GDL_77 GDL_76 GDL_75
+  GDL_74 GDL_73 GDL_72 GDL_71 GDL_70 GDL_69 GDL_68 GDL_67 GDL_66 GDL_65
+  GDL_64 NBIT_A_255 NBIT_A_254 NBIT_A_253 NBIT_A_252 NBIT_A_251 NBIT_A_250
+  NBIT_A_249 NBIT_A_248 NBIT_A_247 NBIT_A_246 NBIT_A_245 NBIT_A_244
+  NBIT_A_243 NBIT_A_242 NBIT_A_241 NBIT_A_240 NBIT_A_239 NBIT_A_238
+  NBIT_A_237 NBIT_A_236 NBIT_A_235 NBIT_A_234 NBIT_A_233 NBIT_A_232
+  NBIT_A_231 NBIT_A_230 NBIT_A_229 NBIT_A_228 NBIT_A_227 NBIT_A_226
+  NBIT_A_225 NBIT_A_224 NBIT_A_223 NBIT_A_222 NBIT_A_221 NBIT_A_220
+  NBIT_A_219 NBIT_A_218 NBIT_A_217 NBIT_A_216 NBIT_A_215 NBIT_A_214
+  NBIT_A_213 NBIT_A_212 NBIT_A_211 NBIT_A_210 NBIT_A_209 NBIT_A_208
+  NBIT_A_207 NBIT_A_206 NBIT_A_205 NBIT_A_204 NBIT_A_203 NBIT_A_202
+  NBIT_A_201 NBIT_A_200 NBIT_A_199 NBIT_A_198 NBIT_A_197 NBIT_A_196
+  NBIT_A_195 NBIT_A_194 NBIT_A_193 NBIT_A_192 NBIT_A_191 NBIT_A_190
+  NBIT_A_189 NBIT_A_188 NBIT_A_187 NBIT_A_186 NBIT_A_185 NBIT_A_184
+  NBIT_A_183 NBIT_A_182 NBIT_A_181 NBIT_A_180 NBIT_A_179 NBIT_A_178
+  NBIT_A_177 NBIT_A_176 NBIT_A_175 NBIT_A_174 NBIT_A_173 NBIT_A_172
+  NBIT_A_171 NBIT_A_170 NBIT_A_169 NBIT_A_168 NBIT_A_167 NBIT_A_166
+  NBIT_A_165 NBIT_A_164 NBIT_A_163 NBIT_A_162 NBIT_A_161 NBIT_A_160
+  NBIT_A_159 NBIT_A_158 NBIT_A_157 NBIT_A_156 NBIT_A_155 NBIT_A_154
+  NBIT_A_153 NBIT_A_152 NBIT_A_151 NBIT_A_150 NBIT_A_149 NBIT_A_148
+  NBIT_A_147 NBIT_A_146 NBIT_A_145 NBIT_A_144 NBIT_A_143 NBIT_A_142
+  NBIT_A_141 NBIT_A_140 NBIT_A_139 NBIT_A_138 NBIT_A_137 NBIT_A_136
+  NBIT_A_135 NBIT_A_134 NBIT_A_133 NBIT_A_132 NBIT_A_131 NBIT_A_130
+  NBIT_A_129 NBIT_A_128 NBIT_B_255 NBIT_B_254 NBIT_B_253 NBIT_B_252
+  NBIT_B_251 NBIT_B_250 NBIT_B_249 NBIT_B_248 NBIT_B_247 NBIT_B_246
+  NBIT_B_245 NBIT_B_244 NBIT_B_243 NBIT_B_242 NBIT_B_241 NBIT_B_240
+  NBIT_B_239 NBIT_B_238 NBIT_B_237 NBIT_B_236 NBIT_B_235 NBIT_B_234
+  NBIT_B_233 NBIT_B_232 NBIT_B_231 NBIT_B_230 NBIT_B_229 NBIT_B_228
+  NBIT_B_227 NBIT_B_226 NBIT_B_225 NBIT_B_224 NBIT_B_223 NBIT_B_222
+  NBIT_B_221 NBIT_B_220 NBIT_B_219 NBIT_B_218 NBIT_B_217 NBIT_B_216
+  NBIT_B_215 NBIT_B_214 NBIT_B_213 NBIT_B_212 NBIT_B_211 NBIT_B_210
+  NBIT_B_209 NBIT_B_208 NBIT_B_207 NBIT_B_206 NBIT_B_205 NBIT_B_204
+  NBIT_B_203 NBIT_B_202 NBIT_B_201 NBIT_B_200 NBIT_B_199 NBIT_B_198
+  NBIT_B_197 NBIT_B_196 NBIT_B_195 NBIT_B_194 NBIT_B_193 NBIT_B_192
+  NBIT_B_191 NBIT_B_190 NBIT_B_189 NBIT_B_188 NBIT_B_187 NBIT_B_186
+  NBIT_B_185 NBIT_B_184 NBIT_B_183 NBIT_B_182 NBIT_B_181 NBIT_B_180
+  NBIT_B_179 NBIT_B_178 NBIT_B_177 NBIT_B_176 NBIT_B_175 NBIT_B_174
+  NBIT_B_173 NBIT_B_172 NBIT_B_171 NBIT_B_170 NBIT_B_169 NBIT_B_168
+  NBIT_B_167 NBIT_B_166 NBIT_B_165 NBIT_B_164 NBIT_B_163 NBIT_B_162
+  NBIT_B_161 NBIT_B_160 NBIT_B_159 NBIT_B_158 NBIT_B_157 NBIT_B_156
+  NBIT_B_155 NBIT_B_154 NBIT_B_153 NBIT_B_152 NBIT_B_151 NBIT_B_150
+  NBIT_B_149 NBIT_B_148 NBIT_B_147 NBIT_B_146 NBIT_B_145 NBIT_B_144
+  NBIT_B_143 NBIT_B_142 NBIT_B_141 NBIT_B_140 NBIT_B_139 NBIT_B_138
+  NBIT_B_137 NBIT_B_136 NBIT_B_135 NBIT_B_134 NBIT_B_133 NBIT_B_132
+  NBIT_B_131 NBIT_B_130 NBIT_B_129 NBIT_B_128 NWGSEL_127 NWGSEL_126
+  NWGSEL_125 NWGSEL_124 NWGSEL_123 NWGSEL_122 NWGSEL_121 NWGSEL_120
+  NWGSEL_119 NWGSEL_118 NWGSEL_117 NWGSEL_116 NWGSEL_115 NWGSEL_114
+  NWGSEL_113 NWGSEL_112 NWGSEL_111 NWGSEL_110 NWGSEL_109 NWGSEL_108
+  NWGSEL_107 NWGSEL_106 NWGSEL_105 NWGSEL_104 NWGSEL_103 NWGSEL_102
+  NWGSEL_101 NWGSEL_100 NWGSEL_99 NWGSEL_98 NWGSEL_97 NWGSEL_96 NWGSEL_95
+  NWGSEL_94 NWGSEL_93 NWGSEL_92 NWGSEL_91 NWGSEL_90 NWGSEL_89 NWGSEL_88
+  NWGSEL_87 NWGSEL_86 NWGSEL_85 NWGSEL_84 NWGSEL_83 NWGSEL_82 NWGSEL_81
+  NWGSEL_80 NWGSEL_79 NWGSEL_78 NWGSEL_77 NWGSEL_76 NWGSEL_75 NWGSEL_74
+  NWGSEL_73 NWGSEL_72 NWGSEL_71 NWGSEL_70 NWGSEL_69 NWGSEL_68 NWGSEL_67
+  NWGSEL_66 NWGSEL_65 NWGSEL_64 VDDCE_255 VDDCE_254 VDDCE_253 VDDCE_252
+  VDDCE_251 VDDCE_250 VDDCE_249 VDDCE_248 VDDCE_247 VDDCE_246 VDDCE_245
+  VDDCE_244 VDDCE_243 VDDCE_242 VDDCE_241 VDDCE_240 VDDCE_239 VDDCE_238
+  VDDCE_237 VDDCE_236 VDDCE_235 VDDCE_234 VDDCE_233 VDDCE_232 VDDCE_231
+  VDDCE_230 VDDCE_229 VDDCE_228 VDDCE_227 VDDCE_226 VDDCE_225 VDDCE_224
+  VDDCE_223 VDDCE_222 VDDCE_221 VDDCE_220 VDDCE_219 VDDCE_218 VDDCE_217
+  VDDCE_216 VDDCE_215 VDDCE_214 VDDCE_213 VDDCE_212 VDDCE_211 VDDCE_210
+  VDDCE_209 VDDCE_208 VDDCE_207 VDDCE_206 VDDCE_205 VDDCE_204 VDDCE_203
+  VDDCE_202 VDDCE_201 VDDCE_200 VDDCE_199 VDDCE_198 VDDCE_197 VDDCE_196
+  VDDCE_195 VDDCE_194 VDDCE_193 VDDCE_192 VDDCE_191 VDDCE_190 VDDCE_189
+  VDDCE_188 VDDCE_187 VDDCE_186 VDDCE_185 VDDCE_184 VDDCE_183 VDDCE_182
+  VDDCE_181 VDDCE_180 VDDCE_179 VDDCE_178 VDDCE_177 VDDCE_176 VDDCE_175
+  VDDCE_174 VDDCE_173 VDDCE_172 VDDCE_171 VDDCE_170 VDDCE_169 VDDCE_168
+  VDDCE_167 VDDCE_166 VDDCE_165 VDDCE_164 VDDCE_163 VDDCE_162 VDDCE_161
+  VDDCE_160 VDDCE_159 VDDCE_158 VDDCE_157 VDDCE_156 VDDCE_155 VDDCE_154
+  VDDCE_153 VDDCE_152 VDDCE_151 VDDCE_150 VDDCE_149 VDDCE_148 VDDCE_147
+  VDDCE_146 VDDCE_145 VDDCE_144 VDDCE_143 VDDCE_142 VDDCE_141 VDDCE_140
+  VDDCE_139 VDDCE_138 VDDCE_137 VDDCE_136 VDDCE_135 VDDCE_134 VDDCE_133
+  VDDCE_132 VDDCE_131 VDDCE_130 VDDCE_129 VDDCE_128 VDDC_255 VDDC_254
+  VDDC_253 VDDC_252 VDDC_251 VDDC_250 VDDC_249 VDDC_248 VDDC_247 VDDC_246
+  VDDC_245 VDDC_244 VDDC_243 VDDC_242 VDDC_241 VDDC_240 VDDC_239 VDDC_238
+  VDDC_237 VDDC_236 VDDC_235 VDDC_234 VDDC_233 VDDC_232 VDDC_231 VDDC_230
+  VDDC_229 VDDC_228 VDDC_227 VDDC_226 VDDC_225 VDDC_224 VDDC_223 VDDC_222
+  VDDC_221 VDDC_220 VDDC_219 VDDC_218 VDDC_217 VDDC_216 VDDC_215 VDDC_214
+  VDDC_213 VDDC_212 VDDC_211 VDDC_210 VDDC_209 VDDC_208 VDDC_207 VDDC_206
+  VDDC_205 VDDC_204 VDDC_203 VDDC_202 VDDC_201 VDDC_200 VDDC_199 VDDC_198
+  VDDC_197 VDDC_196 VDDC_195 VDDC_194 VDDC_193 VDDC_192 VDDC_191 VDDC_190
+  VDDC_189 VDDC_188 VDDC_187 VDDC_186 VDDC_185 VDDC_184 VDDC_183 VDDC_182
+  VDDC_181 VDDC_180 VDDC_179 VDDC_178 VDDC_177 VDDC_176 VDDC_175 VDDC_174
+  VDDC_173 VDDC_172 VDDC_171 VDDC_170 VDDC_169 VDDC_168 VDDC_167 VDDC_166
+  VDDC_165 VDDC_164 VDDC_163 VDDC_162 VDDC_161 VDDC_160 VDDC_159 VDDC_158
+  VDDC_157 VDDC_156 VDDC_155 VDDC_154 VDDC_153 VDDC_152 VDDC_151 VDDC_150
+  VDDC_149 VDDC_148 VDDC_147 VDDC_146 VDDC_145 VDDC_144 VDDC_143 VDDC_142
+  VDDC_141 VDDC_140 VDDC_139 VDDC_138 VDDC_137 VDDC_136 VDDC_135 VDDC_134
+  VDDC_133 VDDC_132 VDDC_131 VDDC_130 VDDC_129 VDDC_128 VDDPE_256 VDDPE_255
+  VDDPE_254 VDDPE_253 VDDPE_252 VDDPE_251 VDDPE_250 VDDPE_249 VDDPE_248
+  VDDPE_247 VDDPE_246 VDDPE_245 VDDPE_244 VDDPE_243 VDDPE_242 VDDPE_241
+  VDDPE_240 VDDPE_239 VDDPE_238 VDDPE_237 VDDPE_236 VDDPE_235 VDDPE_234
+  VDDPE_233 VDDPE_232 VDDPE_231 VDDPE_230 VDDPE_229 VDDPE_228 VDDPE_227
+  VDDPE_226 VDDPE_225 VDDPE_224 VDDPE_223 VDDPE_222 VDDPE_221 VDDPE_220
+  VDDPE_219 VDDPE_218 VDDPE_217 VDDPE_216 VDDPE_215 VDDPE_214 VDDPE_213
+  VDDPE_212 VDDPE_211 VDDPE_210 VDDPE_209 VDDPE_208 VDDPE_207 VDDPE_206
+  VDDPE_205 VDDPE_204 VDDPE_203 VDDPE_202 VDDPE_201 VDDPE_200 VDDPE_199
+  VDDPE_198 VDDPE_197 VDDPE_196 VDDPE_195 VDDPE_194 VDDPE_193 VDDPE_192
+  VDDPE_191 VDDPE_190 VDDPE_189 VDDPE_188 VDDPE_187 VDDPE_186 VDDPE_185
+  VDDPE_184 VDDPE_183 VDDPE_182 VDDPE_181 VDDPE_180 VDDPE_179 VDDPE_178
+  VDDPE_177 VDDPE_176 VDDPE_175 VDDPE_174 VDDPE_173 VDDPE_172 VDDPE_171
+  VDDPE_170 VDDPE_169 VDDPE_168 VDDPE_167 VDDPE_166 VDDPE_165 VDDPE_164
+  VDDPE_163 VDDPE_162 VDDPE_161 VDDPE_160 VDDPE_159 VDDPE_158 VDDPE_157
+  VDDPE_156 VDDPE_155 VDDPE_154 VDDPE_153 VDDPE_152 VDDPE_151 VDDPE_150
+  VDDPE_149 VDDPE_148 VDDPE_147 VDDPE_146 VDDPE_145 VDDPE_144 VDDPE_143
+  VDDPE_142 VDDPE_141 VDDPE_140 VDDPE_139 VDDPE_138 VDDPE_137 VDDPE_136
+  VDDPE_135 VDDPE_134 VDDPE_133 VDDPE_132 VDDPE_131 VDDPE_130 VDDPE_129
+  VNWC_257 VNWC_256 VNWC_255 VNWC_254 VNWC_253 VNWC_252 VNWC_251 VNWC_250
+  VNWC_249 VNWC_248 VNWC_247 VNWC_246 VNWC_245 VNWC_244 VNWC_243 VNWC_242
+  VNWC_241 VNWC_240 VNWC_239 VNWC_238 VNWC_237 VNWC_236 VNWC_235 VNWC_234
+  VNWC_233 VNWC_232 VNWC_231 VNWC_230 VNWC_229 VNWC_228 VNWC_227 VNWC_226
+  VNWC_225 VNWC_224 VNWC_223 VNWC_222 VNWC_221 VNWC_220 VNWC_219 VNWC_218
+  VNWC_217 VNWC_216 VNWC_215 VNWC_214 VNWC_213 VNWC_212 VNWC_211 VNWC_210
+  VNWC_209 VNWC_208 VNWC_207 VNWC_206 VNWC_205 VNWC_204 VNWC_203 VNWC_202
+  VNWC_201 VNWC_200 VNWC_199 VNWC_198 VNWC_197 VNWC_196 VNWC_195 VNWC_194
+  VNWC_193 VNWC_192 VNWC_191 VNWC_190 VNWC_189 VNWC_188 VNWC_187 VNWC_186
+  VNWC_185 VNWC_184 VNWC_183 VNWC_182 VNWC_181 VNWC_180 VNWC_179 VNWC_178
+  VNWC_177 VNWC_176 VNWC_175 VNWC_174 VNWC_173 VNWC_172 VNWC_171 VNWC_170
+  VNWC_169 VNWC_168 VNWC_167 VNWC_166 VNWC_165 VNWC_164 VNWC_163 VNWC_162
+  VNWC_161 VNWC_160 VNWC_159 VNWC_158 VNWC_157 VNWC_156 VNWC_155 VNWC_154
+  VNWC_153 VNWC_152 VNWC_151 VNWC_150 VNWC_149 VNWC_148 VNWC_147 VNWC_146
+  VNWC_145 VNWC_144 VNWC_143 VNWC_142 VNWC_141 VNWC_140 VNWC_139 VNWC_138
+  VNWC_137 VNWC_136 VNWC_135 VNWC_134 VNWC_133 VNWC_132 VNWC_131 VNWC_130
+  VPW_256 VPW_255 VPW_254 VPW_253 VPW_252 VPW_251 VPW_250 VPW_249 VPW_248
+  VPW_247 VPW_246 VPW_245 VPW_244 VPW_243 VPW_242 VPW_241 VPW_240 VPW_239
+  VPW_238 VPW_237 VPW_236 VPW_235 VPW_234 VPW_233 VPW_232 VPW_231 VPW_230
+  VPW_229 VPW_228 VPW_227 VPW_226 VPW_225 VPW_224 VPW_223 VPW_222 VPW_221
+  VPW_220 VPW_219 VPW_218 VPW_217 VPW_216 VPW_215 VPW_214 VPW_213 VPW_212
+  VPW_211 VPW_210 VPW_209 VPW_208 VPW_207 VPW_206 VPW_205 VPW_204 VPW_203
+  VPW_202 VPW_201 VPW_200 VPW_199 VPW_198 VPW_197 VPW_196 VPW_195 VPW_194
+  VPW_193 VPW_192 VPW_191 VPW_190 VPW_189 VPW_188 VPW_187 VPW_186 VPW_185
+  VPW_184 VPW_183 VPW_182 VPW_181 VPW_180 VPW_179 VPW_178 VPW_177 VPW_176
+  VPW_175 VPW_174 VPW_173 VPW_172 VPW_171 VPW_170 VPW_169 VPW_168 VPW_167
+  VPW_166 VPW_165 VPW_164 VPW_163 VPW_162 VPW_161 VPW_160 VPW_159 VPW_158
+  VPW_157 VPW_156 VPW_155 VPW_154 VPW_153 VPW_152 VPW_151 VPW_150 VPW_149
+  VPW_148 VPW_147 VPW_146 VPW_145 VPW_144 VPW_143 VPW_142 VPW_141 VPW_140
+  VPW_139 VPW_138 VPW_137 VPW_136 VPW_135 VPW_134 VPW_133 VPW_132 VPW_131
+  VPW_130 VPW_129 VPW_0 WL_A[0]_0 WL_A[1]_0 WL_A[2]_0 WL_A[3]_0 WL_A[0]_1
+  WL_A[1]_1 WL_A[2]_1 WL_A[3]_1 WL_A[0]_2 WL_A[1]_2 WL_A[2]_2 WL_A[3]_2
+  WL_A[0]_3 WL_A[1]_3 WL_A[2]_3 WL_A[3]_3 WL_A[0]_4 WL_A[1]_4 WL_A[2]_4
+  WL_A[3]_4 WL_A[0]_5 WL_A[1]_5 WL_A[2]_5 WL_A[3]_5 WL_A[0]_6 WL_A[1]_6
+  WL_A[2]_6 WL_A[3]_6 WL_A[0]_7 WL_A[1]_7 WL_A[2]_7 WL_A[3]_7 WL_A[0]_8
+  WL_A[1]_8 WL_A[2]_8 WL_A[3]_8 WL_A[0]_9 WL_A[1]_9 WL_A[2]_9 WL_A[3]_9
+  WL_A[0]_10 WL_A[1]_10 WL_A[2]_10 WL_A[3]_10 WL_A[0]_11 WL_A[1]_11
+  WL_A[2]_11 WL_A[3]_11 WL_A[0]_12 WL_A[1]_12 WL_A[2]_12 WL_A[3]_12
+  WL_A[0]_13 WL_A[1]_13 WL_A[2]_13 WL_A[3]_13 WL_A[0]_14 WL_A[1]_14
+  WL_A[2]_14 WL_A[3]_14 WL_A[0]_15 WL_A[1]_15 WL_A[2]_15 WL_A[3]_15 WL_B[0]_0
+  WL_B[1]_0 WL_B[2]_0 WL_B[3]_0 WL_B[0]_1 WL_B[1]_1 WL_B[2]_1 WL_B[3]_1
+  WL_B[0]_2 WL_B[1]_2 WL_B[2]_2 WL_B[3]_2 WL_B[0]_3 WL_B[1]_3 WL_B[2]_3
+  WL_B[3]_3 WL_B[0]_4 WL_B[1]_4 WL_B[2]_4 WL_B[3]_4 WL_B[0]_5 WL_B[1]_5
+  WL_B[2]_5 WL_B[3]_5 WL_B[0]_6 WL_B[1]_6 WL_B[2]_6 WL_B[3]_6 WL_B[0]_7
+  WL_B[1]_7 WL_B[2]_7 WL_B[3]_7 WL_B[0]_8 WL_B[1]_8 WL_B[2]_8 WL_B[3]_8
+  WL_B[0]_9 WL_B[1]_9 WL_B[2]_9 WL_B[3]_9 WL_B[0]_10 WL_B[1]_10 WL_B[2]_10
+  WL_B[3]_10 WL_B[0]_11 WL_B[1]_11 WL_B[2]_11 WL_B[3]_11 WL_B[0]_12
+  WL_B[1]_12 WL_B[2]_12 WL_B[3]_12 WL_B[0]_13 WL_B[1]_13 WL_B[2]_13
+  WL_B[3]_13 WL_B[0]_14 WL_B[1]_14 WL_B[2]_14 WL_B[3]_14 WL_B[0]_15
+  WL_B[1]_15 WL_B[2]_15 WL_B[3]_15 SRAMdpw64d256CARRAY_64_32R
XROWDECCOL ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DBL_A DBL_B LOG0_DBL_A LOG0_DBL_B NACT NDFTRAMBYP_A
+  NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A
+  NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDPE_128 VNWC_129
+  VPW_0 WE_A WE_B WL_A[0]_0 WL_A[0]_2 WL_A[0]_4 WL_A[0]_6 WL_A[0]_8
+  WL_A[0]_10 WL_A[0]_12 WL_A[0]_14 WL_A[1]_0 WL_A[1]_2 WL_A[1]_4 WL_A[1]_6
+  WL_A[1]_8 WL_A[1]_10 WL_A[1]_12 WL_A[1]_14 WL_A[2]_0 WL_A[2]_2 WL_A[2]_4
+  WL_A[2]_6 WL_A[2]_8 WL_A[2]_10 WL_A[2]_12 WL_A[2]_14 WL_A[3]_0 WL_A[3]_2
+  WL_A[3]_4 WL_A[3]_6 WL_A[3]_8 WL_A[3]_10 WL_A[3]_12 WL_A[3]_14 WL_A[0]_1
+  WL_A[0]_3 WL_A[0]_5 WL_A[0]_7 WL_A[0]_9 WL_A[0]_11 WL_A[0]_13 WL_A[0]_15
+  WL_A[1]_1 WL_A[1]_3 WL_A[1]_5 WL_A[1]_7 WL_A[1]_9 WL_A[1]_11 WL_A[1]_13
+  WL_A[1]_15 WL_A[2]_1 WL_A[2]_3 WL_A[2]_5 WL_A[2]_7 WL_A[2]_9 WL_A[2]_11
+  WL_A[2]_13 WL_A[2]_15 WL_A[3]_1 WL_A[3]_3 WL_A[3]_5 WL_A[3]_7 WL_A[3]_9
+  WL_A[3]_11 WL_A[3]_13 WL_A[3]_15 WL_B[0]_0 WL_B[0]_2 WL_B[0]_4 WL_B[0]_6
+  WL_B[0]_8 WL_B[0]_10 WL_B[0]_12 WL_B[0]_14 WL_B[1]_0 WL_B[1]_2 WL_B[1]_4
+  WL_B[1]_6 WL_B[1]_8 WL_B[1]_10 WL_B[1]_12 WL_B[1]_14 WL_B[2]_0 WL_B[2]_2
+  WL_B[2]_4 WL_B[2]_6 WL_B[2]_8 WL_B[2]_10 WL_B[2]_12 WL_B[2]_14 WL_B[3]_0
+  WL_B[3]_2 WL_B[3]_4 WL_B[3]_6 WL_B[3]_8 WL_B[3]_10 WL_B[3]_12 WL_B[3]_14
+  WL_B[0]_1 WL_B[0]_3 WL_B[0]_5 WL_B[0]_7 WL_B[0]_9 WL_B[0]_11 WL_B[0]_13
+  WL_B[0]_15 WL_B[1]_1 WL_B[1]_3 WL_B[1]_5 WL_B[1]_7 WL_B[1]_9 WL_B[1]_11
+  WL_B[1]_13 WL_B[1]_15 WL_B[2]_1 WL_B[2]_3 WL_B[2]_5 WL_B[2]_7 WL_B[2]_9
+  WL_B[2]_11 WL_B[2]_13 WL_B[2]_15 WL_B[3]_1 WL_B[3]_3 WL_B[3]_5 WL_B[3]_7
+  WL_B[3]_9 WL_B[3]_11 WL_B[3]_13 WL_B[3]_15 WRA_MA WRB_MA WTE_A WTE_B
+  SRAMdpw64d256ROWCH64
.ENDS SRAMdpw64d256ARRAY_64_32_32
****
.SUBCKT SRAMdpw64d256EDGE_CNTL_NOTCH ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BNK_A BNK_B CLK_A CLK_B DBL_A DBL_B LOG0_DBL_A
+  LOG0_DBL_B NACT NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B
+  NRDT_A NRDT_B NRETHVT NRETNVT NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1]
+  RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A
+  RE_B VDDC VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDCE VDDPE VNWC VNWP VPW VSSE WE_A
+  WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256EDGE_CNTL_NOTCH: 8 flat devices **
X_MXP0 VDDCB2 NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.24U L=0.04U
X_MXP1 VDDCA1 NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.27U L=0.04U
X_MXP10 RET_SHR_DEC1B[1] RETB[1] VDDPE VNWC P11LL_CKT W=3.555U L=0.04U
X_MXP4 VDDCA2 NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.24U L=0.04U
X_MXP5 VDDCB1 NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.225U L=0.04U
X_MXP6 RET_SHR_DEC1A[1] RETA[1] VDDPE VNWC P11LL_CKT W=3.57U L=0.04U
X_MXP7 RET_SHR_DEC1A[0] RETA[0] VDDPE VNWC P11LL_CKT W=3.555U L=0.04U
X_MXP9 RET_SHR_DEC1B[0] RETB[0] VDDPE VNWC P11LL_CKT W=3.57U L=0.04U
.ENDS SRAMdpw64d256EDGE_CNTL_NOTCH
****
.SUBCKT SRAMdpw64d256CCCAPI4 BIT_A[0] BIT_A[1] BIT_A[2] BIT_A[3] BIT_B[0]
+  BIT_B[1] BIT_B[2] BIT_B[3] DATAIN_A DATAIN_B GDL_A GDL_B NBIT_A[0]
+  NBIT_A[1] NBIT_A[2] NBIT_A[3] NBIT_B[0] NBIT_B[1] NBIT_B[2] NBIT_B[3]
+  NWGSEL_A NWGSEL_B VDDC VDDCE VDDPE VNWC VPW VSSE
** SRAMdpw64d256CCCAPI4: 48 flat devices **
X_MXN12 NET99 VPW BIT_B[3] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN14 NET95 VPW BIT_B[2] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN15 NBIT_B[3] VPW NET92 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN16 NBIT_B[2] VPW NET88 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN18 NBIT_B[0] VPW NET80 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN38 VPW VPW NET104 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN39 VPW VPW NET108 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN4 NET0163 NET0165 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN40 NET0143 NET0145 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN41 VPW NET097 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN42 VPW NET089 NET0136 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN43 VPW NET085 NET0148 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN44 VPW NET0105 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN45 VSSE NET0153 NET0152 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN46 VPW VPW NET112 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN47 VPW NET073 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN48 VPW VPW NET116 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN49 NET83 VPW BIT_B[0] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN50 NBIT_B[1] VPW NET76 VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN51 NET71 VPW BIT_B[1] VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN52 VPW VPW NET120 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN53 VPW VPW NET136 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN54 VPW VPW NET124 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN55 VPW VPW NET140 VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN56 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN57 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN58 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN59 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN60 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN61 VPW VPW VPW VPW dpcnfetwla_ckt W=0.154U L=0.067U
X_MXN62 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN63 VPW NET0109 VPW VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN64 VPW VPW VPW VPW dpcnfetwlb_ckt W=0.154U L=0.067U
X_MXN65 VPW NET0113 NET0156 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN66 VPW NET081 NET0124 VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXN67 NET0119 NET0121 VSSE VPW dpcnfetpd_ckt W=0.305U L=0.055U
X_MXP11 NET092 NET0145 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP12 VNWC NET097 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP13 NET088 NET089 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP14 NET084 NET085 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP15 VNWC NET0105 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP16 NET0100 NET0153 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP17 NET076 NET0121 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP18 VNWC NET073 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP19 NET080 NET081 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP7 NET0112 NET0113 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP8 VNWC NET0109 VNWC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
X_MXP9 NET0116 NET0165 VDDC VNWC dpcpfetpu_ckt W=0.06U L=0.055U
.ENDS SRAMdpw64d256CCCAPI4
****
.SUBCKT SRAMdpw64d256CCIIO032O BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3
+  BIT_A[0]_4 BIT_A[0]_5 BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9
+  BIT_A[0]_10 BIT_A[0]_11 BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15
+  BIT_A[0]_16 BIT_A[0]_17 BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21
+  BIT_A[0]_22 BIT_A[0]_23 BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27
+  BIT_A[0]_28 BIT_A[0]_29 BIT_A[0]_30 BIT_A[0]_31 BIT_A[1]_0 BIT_A[1]_1
+  BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6 BIT_A[1]_7
+  BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12 BIT_A[1]_13
+  BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18 BIT_A[1]_19
+  BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24 BIT_A[1]_25
+  BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30 BIT_A[1]_31
+  BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2 BIT_A[2]_3 BIT_A[2]_4 BIT_A[2]_5
+  BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8 BIT_A[2]_9 BIT_A[2]_10 BIT_A[2]_11
+  BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14 BIT_A[2]_15 BIT_A[2]_16 BIT_A[2]_17
+  BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20 BIT_A[2]_21 BIT_A[2]_22 BIT_A[2]_23
+  BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26 BIT_A[2]_27 BIT_A[2]_28 BIT_A[2]_29
+  BIT_A[2]_30 BIT_A[2]_31 BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3
+  BIT_A[3]_4 BIT_A[3]_5 BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9
+  BIT_A[3]_10 BIT_A[3]_11 BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15
+  BIT_A[3]_16 BIT_A[3]_17 BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21
+  BIT_A[3]_22 BIT_A[3]_23 BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27
+  BIT_A[3]_28 BIT_A[3]_29 BIT_A[3]_30 BIT_A[3]_31 BIT_B[0]_0 BIT_B[0]_1
+  BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6 BIT_B[0]_7
+  BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12 BIT_B[0]_13
+  BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18 BIT_B[0]_19
+  BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24 BIT_B[0]_25
+  BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30 BIT_B[0]_31
+  BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2 BIT_B[1]_3 BIT_B[1]_4 BIT_B[1]_5
+  BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8 BIT_B[1]_9 BIT_B[1]_10 BIT_B[1]_11
+  BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14 BIT_B[1]_15 BIT_B[1]_16 BIT_B[1]_17
+  BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20 BIT_B[1]_21 BIT_B[1]_22 BIT_B[1]_23
+  BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26 BIT_B[1]_27 BIT_B[1]_28 BIT_B[1]_29
+  BIT_B[1]_30 BIT_B[1]_31 BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3
+  BIT_B[2]_4 BIT_B[2]_5 BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9
+  BIT_B[2]_10 BIT_B[2]_11 BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15
+  BIT_B[2]_16 BIT_B[2]_17 BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21
+  BIT_B[2]_22 BIT_B[2]_23 BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27
+  BIT_B[2]_28 BIT_B[2]_29 BIT_B[2]_30 BIT_B[2]_31 BIT_B[3]_0 BIT_B[3]_1
+  BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6 BIT_B[3]_7
+  BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12 BIT_B[3]_13
+  BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18 BIT_B[3]_19
+  BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24 BIT_B[3]_25
+  BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30 BIT_B[3]_31
+  DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5
+  DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11
+  DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17
+  DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23
+  DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29
+  DATAIN_A_30 DATAIN_A_31 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3
+  DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9
+  DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15
+  DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21
+  DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27
+  DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 GDL_A_0 GDL_A_1 GDL_A_2
+  GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11
+  GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19
+  GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27
+  GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4
+  GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13
+  GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21
+  GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29
+  GDL_B_30 GDL_B_31 NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2 NBIT_A[0]_3
+  NBIT_A[0]_4 NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8 NBIT_A[0]_9
+  NBIT_A[0]_10 NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13 NBIT_A[0]_14
+  NBIT_A[0]_15 NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18 NBIT_A[0]_19
+  NBIT_A[0]_20 NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23 NBIT_A[0]_24
+  NBIT_A[0]_25 NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28 NBIT_A[0]_29
+  NBIT_A[0]_30 NBIT_A[0]_31 NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2 NBIT_A[1]_3
+  NBIT_A[1]_4 NBIT_A[1]_5 NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8 NBIT_A[1]_9
+  NBIT_A[1]_10 NBIT_A[1]_11 NBIT_A[1]_12 NBIT_A[1]_13 NBIT_A[1]_14
+  NBIT_A[1]_15 NBIT_A[1]_16 NBIT_A[1]_17 NBIT_A[1]_18 NBIT_A[1]_19
+  NBIT_A[1]_20 NBIT_A[1]_21 NBIT_A[1]_22 NBIT_A[1]_23 NBIT_A[1]_24
+  NBIT_A[1]_25 NBIT_A[1]_26 NBIT_A[1]_27 NBIT_A[1]_28 NBIT_A[1]_29
+  NBIT_A[1]_30 NBIT_A[1]_31 NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3
+  NBIT_A[2]_4 NBIT_A[2]_5 NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9
+  NBIT_A[2]_10 NBIT_A[2]_11 NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14
+  NBIT_A[2]_15 NBIT_A[2]_16 NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19
+  NBIT_A[2]_20 NBIT_A[2]_21 NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24
+  NBIT_A[2]_25 NBIT_A[2]_26 NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29
+  NBIT_A[2]_30 NBIT_A[2]_31 NBIT_A[3]_0 NBIT_A[3]_1 NBIT_A[3]_2 NBIT_A[3]_3
+  NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7 NBIT_A[3]_8 NBIT_A[3]_9
+  NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13 NBIT_A[3]_14
+  NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18 NBIT_A[3]_19
+  NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23 NBIT_A[3]_24
+  NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28 NBIT_A[3]_29
+  NBIT_A[3]_30 NBIT_A[3]_31 NBIT_B[0]_0 NBIT_B[0]_1 NBIT_B[0]_2 NBIT_B[0]_3
+  NBIT_B[0]_4 NBIT_B[0]_5 NBIT_B[0]_6 NBIT_B[0]_7 NBIT_B[0]_8 NBIT_B[0]_9
+  NBIT_B[0]_10 NBIT_B[0]_11 NBIT_B[0]_12 NBIT_B[0]_13 NBIT_B[0]_14
+  NBIT_B[0]_15 NBIT_B[0]_16 NBIT_B[0]_17 NBIT_B[0]_18 NBIT_B[0]_19
+  NBIT_B[0]_20 NBIT_B[0]_21 NBIT_B[0]_22 NBIT_B[0]_23 NBIT_B[0]_24
+  NBIT_B[0]_25 NBIT_B[0]_26 NBIT_B[0]_27 NBIT_B[0]_28 NBIT_B[0]_29
+  NBIT_B[0]_30 NBIT_B[0]_31 NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3
+  NBIT_B[1]_4 NBIT_B[1]_5 NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9
+  NBIT_B[1]_10 NBIT_B[1]_11 NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14
+  NBIT_B[1]_15 NBIT_B[1]_16 NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19
+  NBIT_B[1]_20 NBIT_B[1]_21 NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24
+  NBIT_B[1]_25 NBIT_B[1]_26 NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29
+  NBIT_B[1]_30 NBIT_B[1]_31 NBIT_B[2]_0 NBIT_B[2]_1 NBIT_B[2]_2 NBIT_B[2]_3
+  NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7 NBIT_B[2]_8 NBIT_B[2]_9
+  NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13 NBIT_B[2]_14
+  NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18 NBIT_B[2]_19
+  NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23 NBIT_B[2]_24
+  NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28 NBIT_B[2]_29
+  NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[3]_0 NBIT_B[3]_1 NBIT_B[3]_2 NBIT_B[3]_3
+  NBIT_B[3]_4 NBIT_B[3]_5 NBIT_B[3]_6 NBIT_B[3]_7 NBIT_B[3]_8 NBIT_B[3]_9
+  NBIT_B[3]_10 NBIT_B[3]_11 NBIT_B[3]_12 NBIT_B[3]_13 NBIT_B[3]_14
+  NBIT_B[3]_15 NBIT_B[3]_16 NBIT_B[3]_17 NBIT_B[3]_18 NBIT_B[3]_19
+  NBIT_B[3]_20 NBIT_B[3]_21 NBIT_B[3]_22 NBIT_B[3]_23 NBIT_B[3]_24
+  NBIT_B[3]_25 NBIT_B[3]_26 NBIT_B[3]_27 NBIT_B[3]_28 NBIT_B[3]_29
+  NBIT_B[3]_30 NBIT_B[3]_31 NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3
+  NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9
+  NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15
+  NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21
+  NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27
+  NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_B_0 NWGSEL_B_1
+  NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7
+  NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13
+  NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19
+  NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25
+  NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31
+  VDDC VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7
+  VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15
+  VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23
+  VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VPW
** SRAMdpw64d256CCIIO032O: 1536 flat devices **
XCCCAPI4LSB0 BIT_A[0]_31 BIT_A[1]_31 BIT_A[2]_31 BIT_A[3]_31 BIT_B[0]_31
+  BIT_B[1]_31 BIT_B[2]_31 BIT_B[3]_31 DATAIN_A_31 DATAIN_B_31 GDL_A_31
+  GDL_B_31 NBIT_A[0]_31 NBIT_A[1]_31 NBIT_A[2]_31 NBIT_A[3]_31 NBIT_B[0]_31
+  NBIT_B[1]_31 NBIT_B[2]_31 NBIT_B[3]_31 NWGSEL_A_31 NWGSEL_B_31 VDDC VDDC
+  VDDPE_31 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4LSB1 BIT_A[0]_30 BIT_A[1]_30 BIT_A[2]_30 BIT_A[3]_30 BIT_B[0]_30
+  BIT_B[1]_30 BIT_B[2]_30 BIT_B[3]_30 DATAIN_A_30 DATAIN_B_30 GDL_A_30
+  GDL_B_30 NBIT_A[0]_30 NBIT_A[1]_30 NBIT_A[2]_30 NBIT_A[3]_30 NBIT_B[0]_30
+  NBIT_B[1]_30 NBIT_B[2]_30 NBIT_B[3]_30 NWGSEL_A_30 NWGSEL_B_30 VDDC VDDC
+  VDDPE_30 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4LSB2 BIT_A[0]_29 BIT_A[1]_29 BIT_A[2]_29 BIT_A[3]_29 BIT_B[0]_29
+  BIT_B[1]_29 BIT_B[2]_29 BIT_B[3]_29 DATAIN_A_29 DATAIN_B_29 GDL_A_29
+  GDL_B_29 NBIT_A[0]_29 NBIT_A[1]_29 NBIT_A[2]_29 NBIT_A[3]_29 NBIT_B[0]_29
+  NBIT_B[1]_29 NBIT_B[2]_29 NBIT_B[3]_29 NWGSEL_A_29 NWGSEL_B_29 VDDC VDDC
+  VDDPE_29 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4LSB3 BIT_A[0]_28 BIT_A[1]_28 BIT_A[2]_28 BIT_A[3]_28 BIT_B[0]_28
+  BIT_B[1]_28 BIT_B[2]_28 BIT_B[3]_28 DATAIN_A_28 DATAIN_B_28 GDL_A_28
+  GDL_B_28 NBIT_A[0]_28 NBIT_A[1]_28 NBIT_A[2]_28 NBIT_A[3]_28 NBIT_B[0]_28
+  NBIT_B[1]_28 NBIT_B[2]_28 NBIT_B[3]_28 NWGSEL_A_28 NWGSEL_B_28 VDDC VDDC
+  VDDPE_28 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4MSB0 BIT_A[0]_3 BIT_A[1]_3 BIT_A[2]_3 BIT_A[3]_3 BIT_B[0]_3 BIT_B[1]_3
+  BIT_B[2]_3 BIT_B[3]_3 DATAIN_A_3 DATAIN_B_3 GDL_A_3 GDL_B_3 NBIT_A[0]_3
+  NBIT_A[1]_3 NBIT_A[2]_3 NBIT_A[3]_3 NBIT_B[0]_3 NBIT_B[1]_3 NBIT_B[2]_3
+  NBIT_B[3]_3 NWGSEL_A_3 NWGSEL_B_3 VDDC VDDC VDDPE_3 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4MSB1 BIT_A[0]_2 BIT_A[1]_2 BIT_A[2]_2 BIT_A[3]_2 BIT_B[0]_2 BIT_B[1]_2
+  BIT_B[2]_2 BIT_B[3]_2 DATAIN_A_2 DATAIN_B_2 GDL_A_2 GDL_B_2 NBIT_A[0]_2
+  NBIT_A[1]_2 NBIT_A[2]_2 NBIT_A[3]_2 NBIT_B[0]_2 NBIT_B[1]_2 NBIT_B[2]_2
+  NBIT_B[3]_2 NWGSEL_A_2 NWGSEL_B_2 VDDC VDDC VDDPE_2 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4MSB2 BIT_A[0]_1 BIT_A[1]_1 BIT_A[2]_1 BIT_A[3]_1 BIT_B[0]_1 BIT_B[1]_1
+  BIT_B[2]_1 BIT_B[3]_1 DATAIN_A_1 DATAIN_B_1 GDL_A_1 GDL_B_1 NBIT_A[0]_1
+  NBIT_A[1]_1 NBIT_A[2]_1 NBIT_A[3]_1 NBIT_B[0]_1 NBIT_B[1]_1 NBIT_B[2]_1
+  NBIT_B[3]_1 NWGSEL_A_1 NWGSEL_B_1 VDDC VDDC VDDPE_1 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4MSB3 BIT_A[0]_0 BIT_A[1]_0 BIT_A[2]_0 BIT_A[3]_0 BIT_B[0]_0 BIT_B[1]_0
+  BIT_B[2]_0 BIT_B[3]_0 DATAIN_A_0 DATAIN_B_0 GDL_A_0 GDL_B_0 NBIT_A[0]_0
+  NBIT_A[1]_0 NBIT_A[2]_0 NBIT_A[3]_0 NBIT_B[0]_0 NBIT_B[1]_0 NBIT_B[2]_0
+  NBIT_B[3]_0 NWGSEL_A_0 NWGSEL_B_0 VDDC VDDC VDDPE_0 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[10] BIT_A[0]_21 BIT_A[1]_21 BIT_A[2]_21 BIT_A[3]_21 BIT_B[0]_21
+  BIT_B[1]_21 BIT_B[2]_21 BIT_B[3]_21 DATAIN_A_21 DATAIN_B_21 GDL_A_21
+  GDL_B_21 NBIT_A[0]_21 NBIT_A[1]_21 NBIT_A[2]_21 NBIT_A[3]_21 NBIT_B[0]_21
+  NBIT_B[1]_21 NBIT_B[2]_21 NBIT_B[3]_21 NWGSEL_A_21 NWGSEL_B_21 VDDC VDDC
+  VDDPE_21 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[11] BIT_A[0]_20 BIT_A[1]_20 BIT_A[2]_20 BIT_A[3]_20 BIT_B[0]_20
+  BIT_B[1]_20 BIT_B[2]_20 BIT_B[3]_20 DATAIN_A_20 DATAIN_B_20 GDL_A_20
+  GDL_B_20 NBIT_A[0]_20 NBIT_A[1]_20 NBIT_A[2]_20 NBIT_A[3]_20 NBIT_B[0]_20
+  NBIT_B[1]_20 NBIT_B[2]_20 NBIT_B[3]_20 NWGSEL_A_20 NWGSEL_B_20 VDDC VDDC
+  VDDPE_20 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[12] BIT_A[0]_19 BIT_A[1]_19 BIT_A[2]_19 BIT_A[3]_19 BIT_B[0]_19
+  BIT_B[1]_19 BIT_B[2]_19 BIT_B[3]_19 DATAIN_A_19 DATAIN_B_19 GDL_A_19
+  GDL_B_19 NBIT_A[0]_19 NBIT_A[1]_19 NBIT_A[2]_19 NBIT_A[3]_19 NBIT_B[0]_19
+  NBIT_B[1]_19 NBIT_B[2]_19 NBIT_B[3]_19 NWGSEL_A_19 NWGSEL_B_19 VDDC VDDC
+  VDDPE_19 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[13] BIT_A[0]_18 BIT_A[1]_18 BIT_A[2]_18 BIT_A[3]_18 BIT_B[0]_18
+  BIT_B[1]_18 BIT_B[2]_18 BIT_B[3]_18 DATAIN_A_18 DATAIN_B_18 GDL_A_18
+  GDL_B_18 NBIT_A[0]_18 NBIT_A[1]_18 NBIT_A[2]_18 NBIT_A[3]_18 NBIT_B[0]_18
+  NBIT_B[1]_18 NBIT_B[2]_18 NBIT_B[3]_18 NWGSEL_A_18 NWGSEL_B_18 VDDC VDDC
+  VDDPE_18 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[14] BIT_A[0]_17 BIT_A[1]_17 BIT_A[2]_17 BIT_A[3]_17 BIT_B[0]_17
+  BIT_B[1]_17 BIT_B[2]_17 BIT_B[3]_17 DATAIN_A_17 DATAIN_B_17 GDL_A_17
+  GDL_B_17 NBIT_A[0]_17 NBIT_A[1]_17 NBIT_A[2]_17 NBIT_A[3]_17 NBIT_B[0]_17
+  NBIT_B[1]_17 NBIT_B[2]_17 NBIT_B[3]_17 NWGSEL_A_17 NWGSEL_B_17 VDDC VDDC
+  VDDPE_17 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[15] BIT_A[0]_16 BIT_A[1]_16 BIT_A[2]_16 BIT_A[3]_16 BIT_B[0]_16
+  BIT_B[1]_16 BIT_B[2]_16 BIT_B[3]_16 DATAIN_A_16 DATAIN_B_16 GDL_A_16
+  GDL_B_16 NBIT_A[0]_16 NBIT_A[1]_16 NBIT_A[2]_16 NBIT_A[3]_16 NBIT_B[0]_16
+  NBIT_B[1]_16 NBIT_B[2]_16 NBIT_B[3]_16 NWGSEL_A_16 NWGSEL_B_16 VDDC VDDC
+  VDDPE_16 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[16] BIT_A[0]_15 BIT_A[1]_15 BIT_A[2]_15 BIT_A[3]_15 BIT_B[0]_15
+  BIT_B[1]_15 BIT_B[2]_15 BIT_B[3]_15 DATAIN_A_15 DATAIN_B_15 GDL_A_15
+  GDL_B_15 NBIT_A[0]_15 NBIT_A[1]_15 NBIT_A[2]_15 NBIT_A[3]_15 NBIT_B[0]_15
+  NBIT_B[1]_15 NBIT_B[2]_15 NBIT_B[3]_15 NWGSEL_A_15 NWGSEL_B_15 VDDC VDDC
+  VDDPE_15 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[17] BIT_A[0]_14 BIT_A[1]_14 BIT_A[2]_14 BIT_A[3]_14 BIT_B[0]_14
+  BIT_B[1]_14 BIT_B[2]_14 BIT_B[3]_14 DATAIN_A_14 DATAIN_B_14 GDL_A_14
+  GDL_B_14 NBIT_A[0]_14 NBIT_A[1]_14 NBIT_A[2]_14 NBIT_A[3]_14 NBIT_B[0]_14
+  NBIT_B[1]_14 NBIT_B[2]_14 NBIT_B[3]_14 NWGSEL_A_14 NWGSEL_B_14 VDDC VDDC
+  VDDPE_14 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[18] BIT_A[0]_13 BIT_A[1]_13 BIT_A[2]_13 BIT_A[3]_13 BIT_B[0]_13
+  BIT_B[1]_13 BIT_B[2]_13 BIT_B[3]_13 DATAIN_A_13 DATAIN_B_13 GDL_A_13
+  GDL_B_13 NBIT_A[0]_13 NBIT_A[1]_13 NBIT_A[2]_13 NBIT_A[3]_13 NBIT_B[0]_13
+  NBIT_B[1]_13 NBIT_B[2]_13 NBIT_B[3]_13 NWGSEL_A_13 NWGSEL_B_13 VDDC VDDC
+  VDDPE_13 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[19] BIT_A[0]_12 BIT_A[1]_12 BIT_A[2]_12 BIT_A[3]_12 BIT_B[0]_12
+  BIT_B[1]_12 BIT_B[2]_12 BIT_B[3]_12 DATAIN_A_12 DATAIN_B_12 GDL_A_12
+  GDL_B_12 NBIT_A[0]_12 NBIT_A[1]_12 NBIT_A[2]_12 NBIT_A[3]_12 NBIT_B[0]_12
+  NBIT_B[1]_12 NBIT_B[2]_12 NBIT_B[3]_12 NWGSEL_A_12 NWGSEL_B_12 VDDC VDDC
+  VDDPE_12 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[20] BIT_A[0]_11 BIT_A[1]_11 BIT_A[2]_11 BIT_A[3]_11 BIT_B[0]_11
+  BIT_B[1]_11 BIT_B[2]_11 BIT_B[3]_11 DATAIN_A_11 DATAIN_B_11 GDL_A_11
+  GDL_B_11 NBIT_A[0]_11 NBIT_A[1]_11 NBIT_A[2]_11 NBIT_A[3]_11 NBIT_B[0]_11
+  NBIT_B[1]_11 NBIT_B[2]_11 NBIT_B[3]_11 NWGSEL_A_11 NWGSEL_B_11 VDDC VDDC
+  VDDPE_11 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[21] BIT_A[0]_10 BIT_A[1]_10 BIT_A[2]_10 BIT_A[3]_10 BIT_B[0]_10
+  BIT_B[1]_10 BIT_B[2]_10 BIT_B[3]_10 DATAIN_A_10 DATAIN_B_10 GDL_A_10
+  GDL_B_10 NBIT_A[0]_10 NBIT_A[1]_10 NBIT_A[2]_10 NBIT_A[3]_10 NBIT_B[0]_10
+  NBIT_B[1]_10 NBIT_B[2]_10 NBIT_B[3]_10 NWGSEL_A_10 NWGSEL_B_10 VDDC VDDC
+  VDDPE_10 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[22] BIT_A[0]_9 BIT_A[1]_9 BIT_A[2]_9 BIT_A[3]_9 BIT_B[0]_9 BIT_B[1]_9
+  BIT_B[2]_9 BIT_B[3]_9 DATAIN_A_9 DATAIN_B_9 GDL_A_9 GDL_B_9 NBIT_A[0]_9
+  NBIT_A[1]_9 NBIT_A[2]_9 NBIT_A[3]_9 NBIT_B[0]_9 NBIT_B[1]_9 NBIT_B[2]_9
+  NBIT_B[3]_9 NWGSEL_A_9 NWGSEL_B_9 VDDC VDDC VDDPE_9 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[23] BIT_A[0]_8 BIT_A[1]_8 BIT_A[2]_8 BIT_A[3]_8 BIT_B[0]_8 BIT_B[1]_8
+  BIT_B[2]_8 BIT_B[3]_8 DATAIN_A_8 DATAIN_B_8 GDL_A_8 GDL_B_8 NBIT_A[0]_8
+  NBIT_A[1]_8 NBIT_A[2]_8 NBIT_A[3]_8 NBIT_B[0]_8 NBIT_B[1]_8 NBIT_B[2]_8
+  NBIT_B[3]_8 NWGSEL_A_8 NWGSEL_B_8 VDDC VDDC VDDPE_8 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[24] BIT_A[0]_7 BIT_A[1]_7 BIT_A[2]_7 BIT_A[3]_7 BIT_B[0]_7 BIT_B[1]_7
+  BIT_B[2]_7 BIT_B[3]_7 DATAIN_A_7 DATAIN_B_7 GDL_A_7 GDL_B_7 NBIT_A[0]_7
+  NBIT_A[1]_7 NBIT_A[2]_7 NBIT_A[3]_7 NBIT_B[0]_7 NBIT_B[1]_7 NBIT_B[2]_7
+  NBIT_B[3]_7 NWGSEL_A_7 NWGSEL_B_7 VDDC VDDC VDDPE_7 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[25] BIT_A[0]_6 BIT_A[1]_6 BIT_A[2]_6 BIT_A[3]_6 BIT_B[0]_6 BIT_B[1]_6
+  BIT_B[2]_6 BIT_B[3]_6 DATAIN_A_6 DATAIN_B_6 GDL_A_6 GDL_B_6 NBIT_A[0]_6
+  NBIT_A[1]_6 NBIT_A[2]_6 NBIT_A[3]_6 NBIT_B[0]_6 NBIT_B[1]_6 NBIT_B[2]_6
+  NBIT_B[3]_6 NWGSEL_A_6 NWGSEL_B_6 VDDC VDDC VDDPE_6 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[26] BIT_A[0]_5 BIT_A[1]_5 BIT_A[2]_5 BIT_A[3]_5 BIT_B[0]_5 BIT_B[1]_5
+  BIT_B[2]_5 BIT_B[3]_5 DATAIN_A_5 DATAIN_B_5 GDL_A_5 GDL_B_5 NBIT_A[0]_5
+  NBIT_A[1]_5 NBIT_A[2]_5 NBIT_A[3]_5 NBIT_B[0]_5 NBIT_B[1]_5 NBIT_B[2]_5
+  NBIT_B[3]_5 NWGSEL_A_5 NWGSEL_B_5 VDDC VDDC VDDPE_5 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[27] BIT_A[0]_4 BIT_A[1]_4 BIT_A[2]_4 BIT_A[3]_4 BIT_B[0]_4 BIT_B[1]_4
+  BIT_B[2]_4 BIT_B[3]_4 DATAIN_A_4 DATAIN_B_4 GDL_A_4 GDL_B_4 NBIT_A[0]_4
+  NBIT_A[1]_4 NBIT_A[2]_4 NBIT_A[3]_4 NBIT_B[0]_4 NBIT_B[1]_4 NBIT_B[2]_4
+  NBIT_B[3]_4 NWGSEL_A_4 NWGSEL_B_4 VDDC VDDC VDDPE_4 VDDC VPW VPW
+  SRAMdpw64d256CCCAPI4
XCCCAPI4[4] BIT_A[0]_27 BIT_A[1]_27 BIT_A[2]_27 BIT_A[3]_27 BIT_B[0]_27
+  BIT_B[1]_27 BIT_B[2]_27 BIT_B[3]_27 DATAIN_A_27 DATAIN_B_27 GDL_A_27
+  GDL_B_27 NBIT_A[0]_27 NBIT_A[1]_27 NBIT_A[2]_27 NBIT_A[3]_27 NBIT_B[0]_27
+  NBIT_B[1]_27 NBIT_B[2]_27 NBIT_B[3]_27 NWGSEL_A_27 NWGSEL_B_27 VDDC VDDC
+  VDDPE_27 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[5] BIT_A[0]_26 BIT_A[1]_26 BIT_A[2]_26 BIT_A[3]_26 BIT_B[0]_26
+  BIT_B[1]_26 BIT_B[2]_26 BIT_B[3]_26 DATAIN_A_26 DATAIN_B_26 GDL_A_26
+  GDL_B_26 NBIT_A[0]_26 NBIT_A[1]_26 NBIT_A[2]_26 NBIT_A[3]_26 NBIT_B[0]_26
+  NBIT_B[1]_26 NBIT_B[2]_26 NBIT_B[3]_26 NWGSEL_A_26 NWGSEL_B_26 VDDC VDDC
+  VDDPE_26 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[6] BIT_A[0]_25 BIT_A[1]_25 BIT_A[2]_25 BIT_A[3]_25 BIT_B[0]_25
+  BIT_B[1]_25 BIT_B[2]_25 BIT_B[3]_25 DATAIN_A_25 DATAIN_B_25 GDL_A_25
+  GDL_B_25 NBIT_A[0]_25 NBIT_A[1]_25 NBIT_A[2]_25 NBIT_A[3]_25 NBIT_B[0]_25
+  NBIT_B[1]_25 NBIT_B[2]_25 NBIT_B[3]_25 NWGSEL_A_25 NWGSEL_B_25 VDDC VDDC
+  VDDPE_25 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[7] BIT_A[0]_24 BIT_A[1]_24 BIT_A[2]_24 BIT_A[3]_24 BIT_B[0]_24
+  BIT_B[1]_24 BIT_B[2]_24 BIT_B[3]_24 DATAIN_A_24 DATAIN_B_24 GDL_A_24
+  GDL_B_24 NBIT_A[0]_24 NBIT_A[1]_24 NBIT_A[2]_24 NBIT_A[3]_24 NBIT_B[0]_24
+  NBIT_B[1]_24 NBIT_B[2]_24 NBIT_B[3]_24 NWGSEL_A_24 NWGSEL_B_24 VDDC VDDC
+  VDDPE_24 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[8] BIT_A[0]_23 BIT_A[1]_23 BIT_A[2]_23 BIT_A[3]_23 BIT_B[0]_23
+  BIT_B[1]_23 BIT_B[2]_23 BIT_B[3]_23 DATAIN_A_23 DATAIN_B_23 GDL_A_23
+  GDL_B_23 NBIT_A[0]_23 NBIT_A[1]_23 NBIT_A[2]_23 NBIT_A[3]_23 NBIT_B[0]_23
+  NBIT_B[1]_23 NBIT_B[2]_23 NBIT_B[3]_23 NWGSEL_A_23 NWGSEL_B_23 VDDC VDDC
+  VDDPE_23 VDDC VPW VPW SRAMdpw64d256CCCAPI4
XCCCAPI4[9] BIT_A[0]_22 BIT_A[1]_22 BIT_A[2]_22 BIT_A[3]_22 BIT_B[0]_22
+  BIT_B[1]_22 BIT_B[2]_22 BIT_B[3]_22 DATAIN_A_22 DATAIN_B_22 GDL_A_22
+  GDL_B_22 NBIT_A[0]_22 NBIT_A[1]_22 NBIT_A[2]_22 NBIT_A[3]_22 NBIT_B[0]_22
+  NBIT_B[1]_22 NBIT_B[2]_22 NBIT_B[3]_22 NWGSEL_A_22 NWGSEL_B_22 VDDC VDDC
+  VDDPE_22 VDDC VPW VPW SRAMdpw64d256CCCAPI4
.ENDS SRAMdpw64d256CCIIO032O
****
.SUBCKT SRAMdpw64d256CCIIO32320 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3 BIT_A[0]_4
+  BIT_A[0]_5 BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9 BIT_A[0]_10
+  BIT_A[0]_11 BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15 BIT_A[0]_16
+  BIT_A[0]_17 BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21 BIT_A[0]_22
+  BIT_A[0]_23 BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27 BIT_A[0]_28
+  BIT_A[0]_29 BIT_A[0]_30 BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34
+  BIT_A[0]_35 BIT_A[0]_36 BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40
+  BIT_A[0]_41 BIT_A[0]_42 BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46
+  BIT_A[0]_47 BIT_A[0]_48 BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52
+  BIT_A[0]_53 BIT_A[0]_54 BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58
+  BIT_A[0]_59 BIT_A[0]_60 BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_0
+  BIT_A[1]_1 BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6
+  BIT_A[1]_7 BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12
+  BIT_A[1]_13 BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18
+  BIT_A[1]_19 BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24
+  BIT_A[1]_25 BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30
+  BIT_A[1]_31 BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35 BIT_A[1]_36
+  BIT_A[1]_37 BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41 BIT_A[1]_42
+  BIT_A[1]_43 BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47 BIT_A[1]_48
+  BIT_A[1]_49 BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53 BIT_A[1]_54
+  BIT_A[1]_55 BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59 BIT_A[1]_60
+  BIT_A[1]_61 BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2
+  BIT_A[2]_3 BIT_A[2]_4 BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8
+  BIT_A[2]_9 BIT_A[2]_10 BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14
+  BIT_A[2]_15 BIT_A[2]_16 BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20
+  BIT_A[2]_21 BIT_A[2]_22 BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26
+  BIT_A[2]_27 BIT_A[2]_28 BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31 BIT_A[2]_32
+  BIT_A[2]_33 BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38
+  BIT_A[2]_39 BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44
+  BIT_A[2]_45 BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50
+  BIT_A[2]_51 BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56
+  BIT_A[2]_57 BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62
+  BIT_A[2]_63 BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3 BIT_A[3]_4
+  BIT_A[3]_5 BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9 BIT_A[3]_10
+  BIT_A[3]_11 BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15 BIT_A[3]_16
+  BIT_A[3]_17 BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21 BIT_A[3]_22
+  BIT_A[3]_23 BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27 BIT_A[3]_28
+  BIT_A[3]_29 BIT_A[3]_30 BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34
+  BIT_A[3]_35 BIT_A[3]_36 BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40
+  BIT_A[3]_41 BIT_A[3]_42 BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46
+  BIT_A[3]_47 BIT_A[3]_48 BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52
+  BIT_A[3]_53 BIT_A[3]_54 BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58
+  BIT_A[3]_59 BIT_A[3]_60 BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_0
+  BIT_B[0]_1 BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6
+  BIT_B[0]_7 BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12
+  BIT_B[0]_13 BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18
+  BIT_B[0]_19 BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24
+  BIT_B[0]_25 BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30
+  BIT_B[0]_31 BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35 BIT_B[0]_36
+  BIT_B[0]_37 BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41 BIT_B[0]_42
+  BIT_B[0]_43 BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47 BIT_B[0]_48
+  BIT_B[0]_49 BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53 BIT_B[0]_54
+  BIT_B[0]_55 BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59 BIT_B[0]_60
+  BIT_B[0]_61 BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2
+  BIT_B[1]_3 BIT_B[1]_4 BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8
+  BIT_B[1]_9 BIT_B[1]_10 BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14
+  BIT_B[1]_15 BIT_B[1]_16 BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20
+  BIT_B[1]_21 BIT_B[1]_22 BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26
+  BIT_B[1]_27 BIT_B[1]_28 BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31 BIT_B[1]_32
+  BIT_B[1]_33 BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38
+  BIT_B[1]_39 BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44
+  BIT_B[1]_45 BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50
+  BIT_B[1]_51 BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56
+  BIT_B[1]_57 BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62
+  BIT_B[1]_63 BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3 BIT_B[2]_4
+  BIT_B[2]_5 BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9 BIT_B[2]_10
+  BIT_B[2]_11 BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15 BIT_B[2]_16
+  BIT_B[2]_17 BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21 BIT_B[2]_22
+  BIT_B[2]_23 BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27 BIT_B[2]_28
+  BIT_B[2]_29 BIT_B[2]_30 BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34
+  BIT_B[2]_35 BIT_B[2]_36 BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40
+  BIT_B[2]_41 BIT_B[2]_42 BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46
+  BIT_B[2]_47 BIT_B[2]_48 BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52
+  BIT_B[2]_53 BIT_B[2]_54 BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58
+  BIT_B[2]_59 BIT_B[2]_60 BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_0
+  BIT_B[3]_1 BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6
+  BIT_B[3]_7 BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12
+  BIT_B[3]_13 BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18
+  BIT_B[3]_19 BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24
+  BIT_B[3]_25 BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30
+  BIT_B[3]_31 BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35 BIT_B[3]_36
+  BIT_B[3]_37 BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41 BIT_B[3]_42
+  BIT_B[3]_43 BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47 BIT_B[3]_48
+  BIT_B[3]_49 BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53 BIT_B[3]_54
+  BIT_B[3]_55 BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59 BIT_B[3]_60
+  BIT_B[3]_61 BIT_B[3]_62 BIT_B[3]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_A_0
+  DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6
+  DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12
+  DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18
+  DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24
+  DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30
+  DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36
+  DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42
+  DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48
+  DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54
+  DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60
+  DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2
+  DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8
+  DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14
+  DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20
+  DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26
+  DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32
+  DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38
+  DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44
+  DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50
+  DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56
+  DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62
+  DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5
+  GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13
+  GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21
+  GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29
+  GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37
+  GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45
+  GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53
+  GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61
+  GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6
+  GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14
+  GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22
+  GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30
+  GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38
+  GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46
+  GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54
+  GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62
+  GDL_B_63 LOG0_DBL_A LOG0_DBL_B NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2
+  NBIT_A[0]_3 NBIT_A[0]_4 NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8
+  NBIT_A[0]_9 NBIT_A[0]_10 NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13
+  NBIT_A[0]_14 NBIT_A[0]_15 NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18
+  NBIT_A[0]_19 NBIT_A[0]_20 NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23
+  NBIT_A[0]_24 NBIT_A[0]_25 NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28
+  NBIT_A[0]_29 NBIT_A[0]_30 NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33
+  NBIT_A[0]_34 NBIT_A[0]_35 NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38
+  NBIT_A[0]_39 NBIT_A[0]_40 NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43
+  NBIT_A[0]_44 NBIT_A[0]_45 NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48
+  NBIT_A[0]_49 NBIT_A[0]_50 NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53
+  NBIT_A[0]_54 NBIT_A[0]_55 NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58
+  NBIT_A[0]_59 NBIT_A[0]_60 NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63
+  NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2 NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5
+  NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8 NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11
+  NBIT_A[1]_12 NBIT_A[1]_13 NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16
+  NBIT_A[1]_17 NBIT_A[1]_18 NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21
+  NBIT_A[1]_22 NBIT_A[1]_23 NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26
+  NBIT_A[1]_27 NBIT_A[1]_28 NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31
+  NBIT_A[1]_32 NBIT_A[1]_33 NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36
+  NBIT_A[1]_37 NBIT_A[1]_38 NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41
+  NBIT_A[1]_42 NBIT_A[1]_43 NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46
+  NBIT_A[1]_47 NBIT_A[1]_48 NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51
+  NBIT_A[1]_52 NBIT_A[1]_53 NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56
+  NBIT_A[1]_57 NBIT_A[1]_58 NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61
+  NBIT_A[1]_62 NBIT_A[1]_63 NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3
+  NBIT_A[2]_4 NBIT_A[2]_5 NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9
+  NBIT_A[2]_10 NBIT_A[2]_11 NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14
+  NBIT_A[2]_15 NBIT_A[2]_16 NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19
+  NBIT_A[2]_20 NBIT_A[2]_21 NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24
+  NBIT_A[2]_25 NBIT_A[2]_26 NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29
+  NBIT_A[2]_30 NBIT_A[2]_31 NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34
+  NBIT_A[2]_35 NBIT_A[2]_36 NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39
+  NBIT_A[2]_40 NBIT_A[2]_41 NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44
+  NBIT_A[2]_45 NBIT_A[2]_46 NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49
+  NBIT_A[2]_50 NBIT_A[2]_51 NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54
+  NBIT_A[2]_55 NBIT_A[2]_56 NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59
+  NBIT_A[2]_60 NBIT_A[2]_61 NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1
+  NBIT_A[3]_2 NBIT_A[3]_3 NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7
+  NBIT_A[3]_8 NBIT_A[3]_9 NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13
+  NBIT_A[3]_14 NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18
+  NBIT_A[3]_19 NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23
+  NBIT_A[3]_24 NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28
+  NBIT_A[3]_29 NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33
+  NBIT_A[3]_34 NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38
+  NBIT_A[3]_39 NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43
+  NBIT_A[3]_44 NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48
+  NBIT_A[3]_49 NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53
+  NBIT_A[3]_54 NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58
+  NBIT_A[3]_59 NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63
+  NBIT_B[0]_0 NBIT_B[0]_1 NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5
+  NBIT_B[0]_6 NBIT_B[0]_7 NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11
+  NBIT_B[0]_12 NBIT_B[0]_13 NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16
+  NBIT_B[0]_17 NBIT_B[0]_18 NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21
+  NBIT_B[0]_22 NBIT_B[0]_23 NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26
+  NBIT_B[0]_27 NBIT_B[0]_28 NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31
+  NBIT_B[0]_32 NBIT_B[0]_33 NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36
+  NBIT_B[0]_37 NBIT_B[0]_38 NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41
+  NBIT_B[0]_42 NBIT_B[0]_43 NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46
+  NBIT_B[0]_47 NBIT_B[0]_48 NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51
+  NBIT_B[0]_52 NBIT_B[0]_53 NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56
+  NBIT_B[0]_57 NBIT_B[0]_58 NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61
+  NBIT_B[0]_62 NBIT_B[0]_63 NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3
+  NBIT_B[1]_4 NBIT_B[1]_5 NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9
+  NBIT_B[1]_10 NBIT_B[1]_11 NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14
+  NBIT_B[1]_15 NBIT_B[1]_16 NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19
+  NBIT_B[1]_20 NBIT_B[1]_21 NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24
+  NBIT_B[1]_25 NBIT_B[1]_26 NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29
+  NBIT_B[1]_30 NBIT_B[1]_31 NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34
+  NBIT_B[1]_35 NBIT_B[1]_36 NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39
+  NBIT_B[1]_40 NBIT_B[1]_41 NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44
+  NBIT_B[1]_45 NBIT_B[1]_46 NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49
+  NBIT_B[1]_50 NBIT_B[1]_51 NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54
+  NBIT_B[1]_55 NBIT_B[1]_56 NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59
+  NBIT_B[1]_60 NBIT_B[1]_61 NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1
+  NBIT_B[2]_2 NBIT_B[2]_3 NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7
+  NBIT_B[2]_8 NBIT_B[2]_9 NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13
+  NBIT_B[2]_14 NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18
+  NBIT_B[2]_19 NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23
+  NBIT_B[2]_24 NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28
+  NBIT_B[2]_29 NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33
+  NBIT_B[2]_34 NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38
+  NBIT_B[2]_39 NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43
+  NBIT_B[2]_44 NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48
+  NBIT_B[2]_49 NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53
+  NBIT_B[2]_54 NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58
+  NBIT_B[2]_59 NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63
+  NBIT_B[3]_0 NBIT_B[3]_1 NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5
+  NBIT_B[3]_6 NBIT_B[3]_7 NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11
+  NBIT_B[3]_12 NBIT_B[3]_13 NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16
+  NBIT_B[3]_17 NBIT_B[3]_18 NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21
+  NBIT_B[3]_22 NBIT_B[3]_23 NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26
+  NBIT_B[3]_27 NBIT_B[3]_28 NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31
+  NBIT_B[3]_32 NBIT_B[3]_33 NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36
+  NBIT_B[3]_37 NBIT_B[3]_38 NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41
+  NBIT_B[3]_42 NBIT_B[3]_43 NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46
+  NBIT_B[3]_47 NBIT_B[3]_48 NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51
+  NBIT_B[3]_52 NBIT_B[3]_53 NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56
+  NBIT_B[3]_57 NBIT_B[3]_58 NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61
+  NBIT_B[3]_62 NBIT_B[3]_63 NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2
+  NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8
+  NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14
+  NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20
+  NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26
+  NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32
+  NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38
+  NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44
+  NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50
+  NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56
+  NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62
+  NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4
+  NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10
+  NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16
+  NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22
+  NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28
+  NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34
+  NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40
+  NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46
+  NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52
+  NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58
+  NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A
+  NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42
+  VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50
+  VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58
+  VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VDDPE_64 VNWC VNWP_0 VNWP_1
+  VNWP_2 VNWP_3 VPW VSSE_0 VSSE_1 VSSE_2 VSSE_3 WE_A WE_B WRA_MA WRB_MA WTE_A
+  WTE_B
** SRAMdpw64d256CCIIO32320: 3080 flat devices **
XEDGE_CNTL_NOTCH ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1]
+  BNK_A BNK_B CLK_A CLK_B DBL_A DBL_B LOG0_DBL_A LOG0_DBL_B NACT NC_RET_ACT
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3]
+  NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0]
+  NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5]
+  NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2]
+  NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7]
+  NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4]
+  NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1]
+  NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2]
+  NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0]
+  RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A RE_B VNWC VDDCA1
+  VDDCA2 VDDCB1 VDDCB2 VNWC VDDPE_32 VNWC VDDPE_32 VPW VPW WE_A WE_B WRA_MA
+  WRB_MA WTE_A WTE_B SRAMdpw64d256EDGE_CNTL_NOTCH
XINNERSUBCHANNEL BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34 BIT_A[0]_35 BIT_A[0]_36
+  BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40 BIT_A[0]_41 BIT_A[0]_42
+  BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46 BIT_A[0]_47 BIT_A[0]_48
+  BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52 BIT_A[0]_53 BIT_A[0]_54
+  BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58 BIT_A[0]_59 BIT_A[0]_60
+  BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34
+  BIT_A[1]_35 BIT_A[1]_36 BIT_A[1]_37 BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40
+  BIT_A[1]_41 BIT_A[1]_42 BIT_A[1]_43 BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46
+  BIT_A[1]_47 BIT_A[1]_48 BIT_A[1]_49 BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52
+  BIT_A[1]_53 BIT_A[1]_54 BIT_A[1]_55 BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58
+  BIT_A[1]_59 BIT_A[1]_60 BIT_A[1]_61 BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_32
+  BIT_A[2]_33 BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38
+  BIT_A[2]_39 BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44
+  BIT_A[2]_45 BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50
+  BIT_A[2]_51 BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56
+  BIT_A[2]_57 BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62
+  BIT_A[2]_63 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34 BIT_A[3]_35 BIT_A[3]_36
+  BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40 BIT_A[3]_41 BIT_A[3]_42
+  BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46 BIT_A[3]_47 BIT_A[3]_48
+  BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52 BIT_A[3]_53 BIT_A[3]_54
+  BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58 BIT_A[3]_59 BIT_A[3]_60
+  BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34
+  BIT_B[0]_35 BIT_B[0]_36 BIT_B[0]_37 BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40
+  BIT_B[0]_41 BIT_B[0]_42 BIT_B[0]_43 BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46
+  BIT_B[0]_47 BIT_B[0]_48 BIT_B[0]_49 BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52
+  BIT_B[0]_53 BIT_B[0]_54 BIT_B[0]_55 BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58
+  BIT_B[0]_59 BIT_B[0]_60 BIT_B[0]_61 BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_32
+  BIT_B[1]_33 BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38
+  BIT_B[1]_39 BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44
+  BIT_B[1]_45 BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50
+  BIT_B[1]_51 BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56
+  BIT_B[1]_57 BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62
+  BIT_B[1]_63 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34 BIT_B[2]_35 BIT_B[2]_36
+  BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40 BIT_B[2]_41 BIT_B[2]_42
+  BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46 BIT_B[2]_47 BIT_B[2]_48
+  BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52 BIT_B[2]_53 BIT_B[2]_54
+  BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58 BIT_B[2]_59 BIT_B[2]_60
+  BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34
+  BIT_B[3]_35 BIT_B[3]_36 BIT_B[3]_37 BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40
+  BIT_B[3]_41 BIT_B[3]_42 BIT_B[3]_43 BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46
+  BIT_B[3]_47 BIT_B[3]_48 BIT_B[3]_49 BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52
+  BIT_B[3]_53 BIT_B[3]_54 BIT_B[3]_55 BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58
+  BIT_B[3]_59 BIT_B[3]_60 BIT_B[3]_61 BIT_B[3]_62 BIT_B[3]_63 DATAIN_A_32
+  DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38
+  DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44
+  DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50
+  DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56
+  DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62
+  DATAIN_A_63 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36
+  DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42
+  DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48
+  DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54
+  DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60
+  DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35
+  GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43
+  GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51
+  GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59
+  GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35
+  GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43
+  GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51
+  GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59
+  GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 NBIT_A[0]_32 NBIT_A[0]_33 NBIT_A[0]_34
+  NBIT_A[0]_35 NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38 NBIT_A[0]_39
+  NBIT_A[0]_40 NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43 NBIT_A[0]_44
+  NBIT_A[0]_45 NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48 NBIT_A[0]_49
+  NBIT_A[0]_50 NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53 NBIT_A[0]_54
+  NBIT_A[0]_55 NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58 NBIT_A[0]_59
+  NBIT_A[0]_60 NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63 NBIT_A[1]_32
+  NBIT_A[1]_33 NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36 NBIT_A[1]_37
+  NBIT_A[1]_38 NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41 NBIT_A[1]_42
+  NBIT_A[1]_43 NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46 NBIT_A[1]_47
+  NBIT_A[1]_48 NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51 NBIT_A[1]_52
+  NBIT_A[1]_53 NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56 NBIT_A[1]_57
+  NBIT_A[1]_58 NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61 NBIT_A[1]_62
+  NBIT_A[1]_63 NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34 NBIT_A[2]_35
+  NBIT_A[2]_36 NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39 NBIT_A[2]_40
+  NBIT_A[2]_41 NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44 NBIT_A[2]_45
+  NBIT_A[2]_46 NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49 NBIT_A[2]_50
+  NBIT_A[2]_51 NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54 NBIT_A[2]_55
+  NBIT_A[2]_56 NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59 NBIT_A[2]_60
+  NBIT_A[2]_61 NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_32 NBIT_A[3]_33
+  NBIT_A[3]_34 NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38
+  NBIT_A[3]_39 NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43
+  NBIT_A[3]_44 NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48
+  NBIT_A[3]_49 NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53
+  NBIT_A[3]_54 NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58
+  NBIT_A[3]_59 NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63
+  NBIT_B[0]_32 NBIT_B[0]_33 NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36
+  NBIT_B[0]_37 NBIT_B[0]_38 NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41
+  NBIT_B[0]_42 NBIT_B[0]_43 NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46
+  NBIT_B[0]_47 NBIT_B[0]_48 NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51
+  NBIT_B[0]_52 NBIT_B[0]_53 NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56
+  NBIT_B[0]_57 NBIT_B[0]_58 NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61
+  NBIT_B[0]_62 NBIT_B[0]_63 NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34
+  NBIT_B[1]_35 NBIT_B[1]_36 NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39
+  NBIT_B[1]_40 NBIT_B[1]_41 NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44
+  NBIT_B[1]_45 NBIT_B[1]_46 NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49
+  NBIT_B[1]_50 NBIT_B[1]_51 NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54
+  NBIT_B[1]_55 NBIT_B[1]_56 NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59
+  NBIT_B[1]_60 NBIT_B[1]_61 NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_32
+  NBIT_B[2]_33 NBIT_B[2]_34 NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37
+  NBIT_B[2]_38 NBIT_B[2]_39 NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42
+  NBIT_B[2]_43 NBIT_B[2]_44 NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47
+  NBIT_B[2]_48 NBIT_B[2]_49 NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52
+  NBIT_B[2]_53 NBIT_B[2]_54 NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57
+  NBIT_B[2]_58 NBIT_B[2]_59 NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62
+  NBIT_B[2]_63 NBIT_B[3]_32 NBIT_B[3]_33 NBIT_B[3]_34 NBIT_B[3]_35
+  NBIT_B[3]_36 NBIT_B[3]_37 NBIT_B[3]_38 NBIT_B[3]_39 NBIT_B[3]_40
+  NBIT_B[3]_41 NBIT_B[3]_42 NBIT_B[3]_43 NBIT_B[3]_44 NBIT_B[3]_45
+  NBIT_B[3]_46 NBIT_B[3]_47 NBIT_B[3]_48 NBIT_B[3]_49 NBIT_B[3]_50
+  NBIT_B[3]_51 NBIT_B[3]_52 NBIT_B[3]_53 NBIT_B[3]_54 NBIT_B[3]_55
+  NBIT_B[3]_56 NBIT_B[3]_57 NBIT_B[3]_58 NBIT_B[3]_59 NBIT_B[3]_60
+  NBIT_B[3]_61 NBIT_B[3]_62 NBIT_B[3]_63 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34
+  NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40
+  NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46
+  NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52
+  NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58
+  NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_32
+  NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38
+  NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44
+  NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50
+  NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56
+  NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62
+  NWGSEL_B_63 VNWC VDDPE_33 VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38
+  VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46
+  VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54
+  VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62
+  VDDPE_63 VDDPE_64 VPW SRAMdpw64d256CCIIO032O
XOUTERSUBCHANNEL BIT_A[0]_31 BIT_A[0]_30 BIT_A[0]_29 BIT_A[0]_28 BIT_A[0]_27
+  BIT_A[0]_26 BIT_A[0]_25 BIT_A[0]_24 BIT_A[0]_23 BIT_A[0]_22 BIT_A[0]_21
+  BIT_A[0]_20 BIT_A[0]_19 BIT_A[0]_18 BIT_A[0]_17 BIT_A[0]_16 BIT_A[0]_15
+  BIT_A[0]_14 BIT_A[0]_13 BIT_A[0]_12 BIT_A[0]_11 BIT_A[0]_10 BIT_A[0]_9
+  BIT_A[0]_8 BIT_A[0]_7 BIT_A[0]_6 BIT_A[0]_5 BIT_A[0]_4 BIT_A[0]_3
+  BIT_A[0]_2 BIT_A[0]_1 BIT_A[0]_0 BIT_A[1]_31 BIT_A[1]_30 BIT_A[1]_29
+  BIT_A[1]_28 BIT_A[1]_27 BIT_A[1]_26 BIT_A[1]_25 BIT_A[1]_24 BIT_A[1]_23
+  BIT_A[1]_22 BIT_A[1]_21 BIT_A[1]_20 BIT_A[1]_19 BIT_A[1]_18 BIT_A[1]_17
+  BIT_A[1]_16 BIT_A[1]_15 BIT_A[1]_14 BIT_A[1]_13 BIT_A[1]_12 BIT_A[1]_11
+  BIT_A[1]_10 BIT_A[1]_9 BIT_A[1]_8 BIT_A[1]_7 BIT_A[1]_6 BIT_A[1]_5
+  BIT_A[1]_4 BIT_A[1]_3 BIT_A[1]_2 BIT_A[1]_1 BIT_A[1]_0 BIT_A[2]_31
+  BIT_A[2]_30 BIT_A[2]_29 BIT_A[2]_28 BIT_A[2]_27 BIT_A[2]_26 BIT_A[2]_25
+  BIT_A[2]_24 BIT_A[2]_23 BIT_A[2]_22 BIT_A[2]_21 BIT_A[2]_20 BIT_A[2]_19
+  BIT_A[2]_18 BIT_A[2]_17 BIT_A[2]_16 BIT_A[2]_15 BIT_A[2]_14 BIT_A[2]_13
+  BIT_A[2]_12 BIT_A[2]_11 BIT_A[2]_10 BIT_A[2]_9 BIT_A[2]_8 BIT_A[2]_7
+  BIT_A[2]_6 BIT_A[2]_5 BIT_A[2]_4 BIT_A[2]_3 BIT_A[2]_2 BIT_A[2]_1
+  BIT_A[2]_0 BIT_A[3]_31 BIT_A[3]_30 BIT_A[3]_29 BIT_A[3]_28 BIT_A[3]_27
+  BIT_A[3]_26 BIT_A[3]_25 BIT_A[3]_24 BIT_A[3]_23 BIT_A[3]_22 BIT_A[3]_21
+  BIT_A[3]_20 BIT_A[3]_19 BIT_A[3]_18 BIT_A[3]_17 BIT_A[3]_16 BIT_A[3]_15
+  BIT_A[3]_14 BIT_A[3]_13 BIT_A[3]_12 BIT_A[3]_11 BIT_A[3]_10 BIT_A[3]_9
+  BIT_A[3]_8 BIT_A[3]_7 BIT_A[3]_6 BIT_A[3]_5 BIT_A[3]_4 BIT_A[3]_3
+  BIT_A[3]_2 BIT_A[3]_1 BIT_A[3]_0 BIT_B[0]_31 BIT_B[0]_30 BIT_B[0]_29
+  BIT_B[0]_28 BIT_B[0]_27 BIT_B[0]_26 BIT_B[0]_25 BIT_B[0]_24 BIT_B[0]_23
+  BIT_B[0]_22 BIT_B[0]_21 BIT_B[0]_20 BIT_B[0]_19 BIT_B[0]_18 BIT_B[0]_17
+  BIT_B[0]_16 BIT_B[0]_15 BIT_B[0]_14 BIT_B[0]_13 BIT_B[0]_12 BIT_B[0]_11
+  BIT_B[0]_10 BIT_B[0]_9 BIT_B[0]_8 BIT_B[0]_7 BIT_B[0]_6 BIT_B[0]_5
+  BIT_B[0]_4 BIT_B[0]_3 BIT_B[0]_2 BIT_B[0]_1 BIT_B[0]_0 BIT_B[1]_31
+  BIT_B[1]_30 BIT_B[1]_29 BIT_B[1]_28 BIT_B[1]_27 BIT_B[1]_26 BIT_B[1]_25
+  BIT_B[1]_24 BIT_B[1]_23 BIT_B[1]_22 BIT_B[1]_21 BIT_B[1]_20 BIT_B[1]_19
+  BIT_B[1]_18 BIT_B[1]_17 BIT_B[1]_16 BIT_B[1]_15 BIT_B[1]_14 BIT_B[1]_13
+  BIT_B[1]_12 BIT_B[1]_11 BIT_B[1]_10 BIT_B[1]_9 BIT_B[1]_8 BIT_B[1]_7
+  BIT_B[1]_6 BIT_B[1]_5 BIT_B[1]_4 BIT_B[1]_3 BIT_B[1]_2 BIT_B[1]_1
+  BIT_B[1]_0 BIT_B[2]_31 BIT_B[2]_30 BIT_B[2]_29 BIT_B[2]_28 BIT_B[2]_27
+  BIT_B[2]_26 BIT_B[2]_25 BIT_B[2]_24 BIT_B[2]_23 BIT_B[2]_22 BIT_B[2]_21
+  BIT_B[2]_20 BIT_B[2]_19 BIT_B[2]_18 BIT_B[2]_17 BIT_B[2]_16 BIT_B[2]_15
+  BIT_B[2]_14 BIT_B[2]_13 BIT_B[2]_12 BIT_B[2]_11 BIT_B[2]_10 BIT_B[2]_9
+  BIT_B[2]_8 BIT_B[2]_7 BIT_B[2]_6 BIT_B[2]_5 BIT_B[2]_4 BIT_B[2]_3
+  BIT_B[2]_2 BIT_B[2]_1 BIT_B[2]_0 BIT_B[3]_31 BIT_B[3]_30 BIT_B[3]_29
+  BIT_B[3]_28 BIT_B[3]_27 BIT_B[3]_26 BIT_B[3]_25 BIT_B[3]_24 BIT_B[3]_23
+  BIT_B[3]_22 BIT_B[3]_21 BIT_B[3]_20 BIT_B[3]_19 BIT_B[3]_18 BIT_B[3]_17
+  BIT_B[3]_16 BIT_B[3]_15 BIT_B[3]_14 BIT_B[3]_13 BIT_B[3]_12 BIT_B[3]_11
+  BIT_B[3]_10 BIT_B[3]_9 BIT_B[3]_8 BIT_B[3]_7 BIT_B[3]_6 BIT_B[3]_5
+  BIT_B[3]_4 BIT_B[3]_3 BIT_B[3]_2 BIT_B[3]_1 BIT_B[3]_0 DATAIN_A_31
+  DATAIN_A_30 DATAIN_A_29 DATAIN_A_28 DATAIN_A_27 DATAIN_A_26 DATAIN_A_25
+  DATAIN_A_24 DATAIN_A_23 DATAIN_A_22 DATAIN_A_21 DATAIN_A_20 DATAIN_A_19
+  DATAIN_A_18 DATAIN_A_17 DATAIN_A_16 DATAIN_A_15 DATAIN_A_14 DATAIN_A_13
+  DATAIN_A_12 DATAIN_A_11 DATAIN_A_10 DATAIN_A_9 DATAIN_A_8 DATAIN_A_7
+  DATAIN_A_6 DATAIN_A_5 DATAIN_A_4 DATAIN_A_3 DATAIN_A_2 DATAIN_A_1
+  DATAIN_A_0 DATAIN_B_31 DATAIN_B_30 DATAIN_B_29 DATAIN_B_28 DATAIN_B_27
+  DATAIN_B_26 DATAIN_B_25 DATAIN_B_24 DATAIN_B_23 DATAIN_B_22 DATAIN_B_21
+  DATAIN_B_20 DATAIN_B_19 DATAIN_B_18 DATAIN_B_17 DATAIN_B_16 DATAIN_B_15
+  DATAIN_B_14 DATAIN_B_13 DATAIN_B_12 DATAIN_B_11 DATAIN_B_10 DATAIN_B_9
+  DATAIN_B_8 DATAIN_B_7 DATAIN_B_6 DATAIN_B_5 DATAIN_B_4 DATAIN_B_3
+  DATAIN_B_2 DATAIN_B_1 DATAIN_B_0 GDL_A_31 GDL_A_30 GDL_A_29 GDL_A_28
+  GDL_A_27 GDL_A_26 GDL_A_25 GDL_A_24 GDL_A_23 GDL_A_22 GDL_A_21 GDL_A_20
+  GDL_A_19 GDL_A_18 GDL_A_17 GDL_A_16 GDL_A_15 GDL_A_14 GDL_A_13 GDL_A_12
+  GDL_A_11 GDL_A_10 GDL_A_9 GDL_A_8 GDL_A_7 GDL_A_6 GDL_A_5 GDL_A_4 GDL_A_3
+  GDL_A_2 GDL_A_1 GDL_A_0 GDL_B_31 GDL_B_30 GDL_B_29 GDL_B_28 GDL_B_27
+  GDL_B_26 GDL_B_25 GDL_B_24 GDL_B_23 GDL_B_22 GDL_B_21 GDL_B_20 GDL_B_19
+  GDL_B_18 GDL_B_17 GDL_B_16 GDL_B_15 GDL_B_14 GDL_B_13 GDL_B_12 GDL_B_11
+  GDL_B_10 GDL_B_9 GDL_B_8 GDL_B_7 GDL_B_6 GDL_B_5 GDL_B_4 GDL_B_3 GDL_B_2
+  GDL_B_1 GDL_B_0 NBIT_A[0]_31 NBIT_A[0]_30 NBIT_A[0]_29 NBIT_A[0]_28
+  NBIT_A[0]_27 NBIT_A[0]_26 NBIT_A[0]_25 NBIT_A[0]_24 NBIT_A[0]_23
+  NBIT_A[0]_22 NBIT_A[0]_21 NBIT_A[0]_20 NBIT_A[0]_19 NBIT_A[0]_18
+  NBIT_A[0]_17 NBIT_A[0]_16 NBIT_A[0]_15 NBIT_A[0]_14 NBIT_A[0]_13
+  NBIT_A[0]_12 NBIT_A[0]_11 NBIT_A[0]_10 NBIT_A[0]_9 NBIT_A[0]_8 NBIT_A[0]_7
+  NBIT_A[0]_6 NBIT_A[0]_5 NBIT_A[0]_4 NBIT_A[0]_3 NBIT_A[0]_2 NBIT_A[0]_1
+  NBIT_A[0]_0 NBIT_A[1]_31 NBIT_A[1]_30 NBIT_A[1]_29 NBIT_A[1]_28
+  NBIT_A[1]_27 NBIT_A[1]_26 NBIT_A[1]_25 NBIT_A[1]_24 NBIT_A[1]_23
+  NBIT_A[1]_22 NBIT_A[1]_21 NBIT_A[1]_20 NBIT_A[1]_19 NBIT_A[1]_18
+  NBIT_A[1]_17 NBIT_A[1]_16 NBIT_A[1]_15 NBIT_A[1]_14 NBIT_A[1]_13
+  NBIT_A[1]_12 NBIT_A[1]_11 NBIT_A[1]_10 NBIT_A[1]_9 NBIT_A[1]_8 NBIT_A[1]_7
+  NBIT_A[1]_6 NBIT_A[1]_5 NBIT_A[1]_4 NBIT_A[1]_3 NBIT_A[1]_2 NBIT_A[1]_1
+  NBIT_A[1]_0 NBIT_A[2]_31 NBIT_A[2]_30 NBIT_A[2]_29 NBIT_A[2]_28
+  NBIT_A[2]_27 NBIT_A[2]_26 NBIT_A[2]_25 NBIT_A[2]_24 NBIT_A[2]_23
+  NBIT_A[2]_22 NBIT_A[2]_21 NBIT_A[2]_20 NBIT_A[2]_19 NBIT_A[2]_18
+  NBIT_A[2]_17 NBIT_A[2]_16 NBIT_A[2]_15 NBIT_A[2]_14 NBIT_A[2]_13
+  NBIT_A[2]_12 NBIT_A[2]_11 NBIT_A[2]_10 NBIT_A[2]_9 NBIT_A[2]_8 NBIT_A[2]_7
+  NBIT_A[2]_6 NBIT_A[2]_5 NBIT_A[2]_4 NBIT_A[2]_3 NBIT_A[2]_2 NBIT_A[2]_1
+  NBIT_A[2]_0 NBIT_A[3]_31 NBIT_A[3]_30 NBIT_A[3]_29 NBIT_A[3]_28
+  NBIT_A[3]_27 NBIT_A[3]_26 NBIT_A[3]_25 NBIT_A[3]_24 NBIT_A[3]_23
+  NBIT_A[3]_22 NBIT_A[3]_21 NBIT_A[3]_20 NBIT_A[3]_19 NBIT_A[3]_18
+  NBIT_A[3]_17 NBIT_A[3]_16 NBIT_A[3]_15 NBIT_A[3]_14 NBIT_A[3]_13
+  NBIT_A[3]_12 NBIT_A[3]_11 NBIT_A[3]_10 NBIT_A[3]_9 NBIT_A[3]_8 NBIT_A[3]_7
+  NBIT_A[3]_6 NBIT_A[3]_5 NBIT_A[3]_4 NBIT_A[3]_3 NBIT_A[3]_2 NBIT_A[3]_1
+  NBIT_A[3]_0 NBIT_B[0]_31 NBIT_B[0]_30 NBIT_B[0]_29 NBIT_B[0]_28
+  NBIT_B[0]_27 NBIT_B[0]_26 NBIT_B[0]_25 NBIT_B[0]_24 NBIT_B[0]_23
+  NBIT_B[0]_22 NBIT_B[0]_21 NBIT_B[0]_20 NBIT_B[0]_19 NBIT_B[0]_18
+  NBIT_B[0]_17 NBIT_B[0]_16 NBIT_B[0]_15 NBIT_B[0]_14 NBIT_B[0]_13
+  NBIT_B[0]_12 NBIT_B[0]_11 NBIT_B[0]_10 NBIT_B[0]_9 NBIT_B[0]_8 NBIT_B[0]_7
+  NBIT_B[0]_6 NBIT_B[0]_5 NBIT_B[0]_4 NBIT_B[0]_3 NBIT_B[0]_2 NBIT_B[0]_1
+  NBIT_B[0]_0 NBIT_B[1]_31 NBIT_B[1]_30 NBIT_B[1]_29 NBIT_B[1]_28
+  NBIT_B[1]_27 NBIT_B[1]_26 NBIT_B[1]_25 NBIT_B[1]_24 NBIT_B[1]_23
+  NBIT_B[1]_22 NBIT_B[1]_21 NBIT_B[1]_20 NBIT_B[1]_19 NBIT_B[1]_18
+  NBIT_B[1]_17 NBIT_B[1]_16 NBIT_B[1]_15 NBIT_B[1]_14 NBIT_B[1]_13
+  NBIT_B[1]_12 NBIT_B[1]_11 NBIT_B[1]_10 NBIT_B[1]_9 NBIT_B[1]_8 NBIT_B[1]_7
+  NBIT_B[1]_6 NBIT_B[1]_5 NBIT_B[1]_4 NBIT_B[1]_3 NBIT_B[1]_2 NBIT_B[1]_1
+  NBIT_B[1]_0 NBIT_B[2]_31 NBIT_B[2]_30 NBIT_B[2]_29 NBIT_B[2]_28
+  NBIT_B[2]_27 NBIT_B[2]_26 NBIT_B[2]_25 NBIT_B[2]_24 NBIT_B[2]_23
+  NBIT_B[2]_22 NBIT_B[2]_21 NBIT_B[2]_20 NBIT_B[2]_19 NBIT_B[2]_18
+  NBIT_B[2]_17 NBIT_B[2]_16 NBIT_B[2]_15 NBIT_B[2]_14 NBIT_B[2]_13
+  NBIT_B[2]_12 NBIT_B[2]_11 NBIT_B[2]_10 NBIT_B[2]_9 NBIT_B[2]_8 NBIT_B[2]_7
+  NBIT_B[2]_6 NBIT_B[2]_5 NBIT_B[2]_4 NBIT_B[2]_3 NBIT_B[2]_2 NBIT_B[2]_1
+  NBIT_B[2]_0 NBIT_B[3]_31 NBIT_B[3]_30 NBIT_B[3]_29 NBIT_B[3]_28
+  NBIT_B[3]_27 NBIT_B[3]_26 NBIT_B[3]_25 NBIT_B[3]_24 NBIT_B[3]_23
+  NBIT_B[3]_22 NBIT_B[3]_21 NBIT_B[3]_20 NBIT_B[3]_19 NBIT_B[3]_18
+  NBIT_B[3]_17 NBIT_B[3]_16 NBIT_B[3]_15 NBIT_B[3]_14 NBIT_B[3]_13
+  NBIT_B[3]_12 NBIT_B[3]_11 NBIT_B[3]_10 NBIT_B[3]_9 NBIT_B[3]_8 NBIT_B[3]_7
+  NBIT_B[3]_6 NBIT_B[3]_5 NBIT_B[3]_4 NBIT_B[3]_3 NBIT_B[3]_2 NBIT_B[3]_1
+  NBIT_B[3]_0 NWGSEL_A_31 NWGSEL_A_30 NWGSEL_A_29 NWGSEL_A_28 NWGSEL_A_27
+  NWGSEL_A_26 NWGSEL_A_25 NWGSEL_A_24 NWGSEL_A_23 NWGSEL_A_22 NWGSEL_A_21
+  NWGSEL_A_20 NWGSEL_A_19 NWGSEL_A_18 NWGSEL_A_17 NWGSEL_A_16 NWGSEL_A_15
+  NWGSEL_A_14 NWGSEL_A_13 NWGSEL_A_12 NWGSEL_A_11 NWGSEL_A_10 NWGSEL_A_9
+  NWGSEL_A_8 NWGSEL_A_7 NWGSEL_A_6 NWGSEL_A_5 NWGSEL_A_4 NWGSEL_A_3
+  NWGSEL_A_2 NWGSEL_A_1 NWGSEL_A_0 NWGSEL_B_31 NWGSEL_B_30 NWGSEL_B_29
+  NWGSEL_B_28 NWGSEL_B_27 NWGSEL_B_26 NWGSEL_B_25 NWGSEL_B_24 NWGSEL_B_23
+  NWGSEL_B_22 NWGSEL_B_21 NWGSEL_B_20 NWGSEL_B_19 NWGSEL_B_18 NWGSEL_B_17
+  NWGSEL_B_16 NWGSEL_B_15 NWGSEL_B_14 NWGSEL_B_13 NWGSEL_B_12 NWGSEL_B_11
+  NWGSEL_B_10 NWGSEL_B_9 NWGSEL_B_8 NWGSEL_B_7 NWGSEL_B_6 NWGSEL_B_5
+  NWGSEL_B_4 NWGSEL_B_3 NWGSEL_B_2 NWGSEL_B_1 NWGSEL_B_0 VNWC VDDPE_31
+  VDDPE_30 VDDPE_29 VDDPE_28 VDDPE_27 VDDPE_26 VDDPE_25 VDDPE_24 VDDPE_23
+  VDDPE_22 VDDPE_21 VDDPE_20 VDDPE_19 VDDPE_18 VDDPE_17 VDDPE_16 VDDPE_15
+  VDDPE_14 VDDPE_13 VDDPE_12 VDDPE_11 VDDPE_10 VDDPE_9 VDDPE_8 VDDPE_7
+  VDDPE_6 VDDPE_5 VDDPE_4 VDDPE_3 VDDPE_2 VDDPE_1 VDDPE_0 VPW
+  SRAMdpw64d256CCIIO032O
.ENDS SRAMdpw64d256CCIIO32320
****
.SUBCKT SRAMdpw64d256ICAPCCIO0 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3 BIT_A[0]_4
+  BIT_A[0]_5 BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9 BIT_A[0]_10
+  BIT_A[0]_11 BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15 BIT_A[0]_16
+  BIT_A[0]_17 BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21 BIT_A[0]_22
+  BIT_A[0]_23 BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27 BIT_A[0]_28
+  BIT_A[0]_29 BIT_A[0]_30 BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34
+  BIT_A[0]_35 BIT_A[0]_36 BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40
+  BIT_A[0]_41 BIT_A[0]_42 BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46
+  BIT_A[0]_47 BIT_A[0]_48 BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52
+  BIT_A[0]_53 BIT_A[0]_54 BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58
+  BIT_A[0]_59 BIT_A[0]_60 BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_0
+  BIT_A[1]_1 BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6
+  BIT_A[1]_7 BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12
+  BIT_A[1]_13 BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18
+  BIT_A[1]_19 BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24
+  BIT_A[1]_25 BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30
+  BIT_A[1]_31 BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35 BIT_A[1]_36
+  BIT_A[1]_37 BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41 BIT_A[1]_42
+  BIT_A[1]_43 BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47 BIT_A[1]_48
+  BIT_A[1]_49 BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53 BIT_A[1]_54
+  BIT_A[1]_55 BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59 BIT_A[1]_60
+  BIT_A[1]_61 BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2
+  BIT_A[2]_3 BIT_A[2]_4 BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8
+  BIT_A[2]_9 BIT_A[2]_10 BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14
+  BIT_A[2]_15 BIT_A[2]_16 BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20
+  BIT_A[2]_21 BIT_A[2]_22 BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26
+  BIT_A[2]_27 BIT_A[2]_28 BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31 BIT_A[2]_32
+  BIT_A[2]_33 BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38
+  BIT_A[2]_39 BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44
+  BIT_A[2]_45 BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50
+  BIT_A[2]_51 BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56
+  BIT_A[2]_57 BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62
+  BIT_A[2]_63 BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3 BIT_A[3]_4
+  BIT_A[3]_5 BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9 BIT_A[3]_10
+  BIT_A[3]_11 BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15 BIT_A[3]_16
+  BIT_A[3]_17 BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21 BIT_A[3]_22
+  BIT_A[3]_23 BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27 BIT_A[3]_28
+  BIT_A[3]_29 BIT_A[3]_30 BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34
+  BIT_A[3]_35 BIT_A[3]_36 BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40
+  BIT_A[3]_41 BIT_A[3]_42 BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46
+  BIT_A[3]_47 BIT_A[3]_48 BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52
+  BIT_A[3]_53 BIT_A[3]_54 BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58
+  BIT_A[3]_59 BIT_A[3]_60 BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_0
+  BIT_B[0]_1 BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6
+  BIT_B[0]_7 BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12
+  BIT_B[0]_13 BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18
+  BIT_B[0]_19 BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24
+  BIT_B[0]_25 BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30
+  BIT_B[0]_31 BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35 BIT_B[0]_36
+  BIT_B[0]_37 BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41 BIT_B[0]_42
+  BIT_B[0]_43 BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47 BIT_B[0]_48
+  BIT_B[0]_49 BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53 BIT_B[0]_54
+  BIT_B[0]_55 BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59 BIT_B[0]_60
+  BIT_B[0]_61 BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2
+  BIT_B[1]_3 BIT_B[1]_4 BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8
+  BIT_B[1]_9 BIT_B[1]_10 BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14
+  BIT_B[1]_15 BIT_B[1]_16 BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20
+  BIT_B[1]_21 BIT_B[1]_22 BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26
+  BIT_B[1]_27 BIT_B[1]_28 BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31 BIT_B[1]_32
+  BIT_B[1]_33 BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38
+  BIT_B[1]_39 BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44
+  BIT_B[1]_45 BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50
+  BIT_B[1]_51 BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56
+  BIT_B[1]_57 BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62
+  BIT_B[1]_63 BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3 BIT_B[2]_4
+  BIT_B[2]_5 BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9 BIT_B[2]_10
+  BIT_B[2]_11 BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15 BIT_B[2]_16
+  BIT_B[2]_17 BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21 BIT_B[2]_22
+  BIT_B[2]_23 BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27 BIT_B[2]_28
+  BIT_B[2]_29 BIT_B[2]_30 BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34
+  BIT_B[2]_35 BIT_B[2]_36 BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40
+  BIT_B[2]_41 BIT_B[2]_42 BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46
+  BIT_B[2]_47 BIT_B[2]_48 BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52
+  BIT_B[2]_53 BIT_B[2]_54 BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58
+  BIT_B[2]_59 BIT_B[2]_60 BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_0
+  BIT_B[3]_1 BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6
+  BIT_B[3]_7 BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12
+  BIT_B[3]_13 BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18
+  BIT_B[3]_19 BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24
+  BIT_B[3]_25 BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30
+  BIT_B[3]_31 BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35 BIT_B[3]_36
+  BIT_B[3]_37 BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41 BIT_B[3]_42
+  BIT_B[3]_43 BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47 BIT_B[3]_48
+  BIT_B[3]_49 BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53 BIT_B[3]_54
+  BIT_B[3]_55 BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59 BIT_B[3]_60
+  BIT_B[3]_61 BIT_B[3]_62 BIT_B[3]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_A_0
+  DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6
+  DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12
+  DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18
+  DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24
+  DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30
+  DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36
+  DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42
+  DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48
+  DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54
+  DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60
+  DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2
+  DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8
+  DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14
+  DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20
+  DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26
+  DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32
+  DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38
+  DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44
+  DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50
+  DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56
+  DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62
+  DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5
+  GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13
+  GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21
+  GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29
+  GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37
+  GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45
+  GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53
+  GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61
+  GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6
+  GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14
+  GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22
+  GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30
+  GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38
+  GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46
+  GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54
+  GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62
+  GDL_B_63 LOG0_DBL_A LOG0_DBL_B NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2
+  NBIT_A[0]_3 NBIT_A[0]_4 NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8
+  NBIT_A[0]_9 NBIT_A[0]_10 NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13
+  NBIT_A[0]_14 NBIT_A[0]_15 NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18
+  NBIT_A[0]_19 NBIT_A[0]_20 NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23
+  NBIT_A[0]_24 NBIT_A[0]_25 NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28
+  NBIT_A[0]_29 NBIT_A[0]_30 NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33
+  NBIT_A[0]_34 NBIT_A[0]_35 NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38
+  NBIT_A[0]_39 NBIT_A[0]_40 NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43
+  NBIT_A[0]_44 NBIT_A[0]_45 NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48
+  NBIT_A[0]_49 NBIT_A[0]_50 NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53
+  NBIT_A[0]_54 NBIT_A[0]_55 NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58
+  NBIT_A[0]_59 NBIT_A[0]_60 NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63
+  NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2 NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5
+  NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8 NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11
+  NBIT_A[1]_12 NBIT_A[1]_13 NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16
+  NBIT_A[1]_17 NBIT_A[1]_18 NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21
+  NBIT_A[1]_22 NBIT_A[1]_23 NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26
+  NBIT_A[1]_27 NBIT_A[1]_28 NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31
+  NBIT_A[1]_32 NBIT_A[1]_33 NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36
+  NBIT_A[1]_37 NBIT_A[1]_38 NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41
+  NBIT_A[1]_42 NBIT_A[1]_43 NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46
+  NBIT_A[1]_47 NBIT_A[1]_48 NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51
+  NBIT_A[1]_52 NBIT_A[1]_53 NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56
+  NBIT_A[1]_57 NBIT_A[1]_58 NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61
+  NBIT_A[1]_62 NBIT_A[1]_63 NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3
+  NBIT_A[2]_4 NBIT_A[2]_5 NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9
+  NBIT_A[2]_10 NBIT_A[2]_11 NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14
+  NBIT_A[2]_15 NBIT_A[2]_16 NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19
+  NBIT_A[2]_20 NBIT_A[2]_21 NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24
+  NBIT_A[2]_25 NBIT_A[2]_26 NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29
+  NBIT_A[2]_30 NBIT_A[2]_31 NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34
+  NBIT_A[2]_35 NBIT_A[2]_36 NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39
+  NBIT_A[2]_40 NBIT_A[2]_41 NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44
+  NBIT_A[2]_45 NBIT_A[2]_46 NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49
+  NBIT_A[2]_50 NBIT_A[2]_51 NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54
+  NBIT_A[2]_55 NBIT_A[2]_56 NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59
+  NBIT_A[2]_60 NBIT_A[2]_61 NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1
+  NBIT_A[3]_2 NBIT_A[3]_3 NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7
+  NBIT_A[3]_8 NBIT_A[3]_9 NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13
+  NBIT_A[3]_14 NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18
+  NBIT_A[3]_19 NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23
+  NBIT_A[3]_24 NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28
+  NBIT_A[3]_29 NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33
+  NBIT_A[3]_34 NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38
+  NBIT_A[3]_39 NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43
+  NBIT_A[3]_44 NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48
+  NBIT_A[3]_49 NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53
+  NBIT_A[3]_54 NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58
+  NBIT_A[3]_59 NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63
+  NBIT_B[0]_0 NBIT_B[0]_1 NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5
+  NBIT_B[0]_6 NBIT_B[0]_7 NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11
+  NBIT_B[0]_12 NBIT_B[0]_13 NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16
+  NBIT_B[0]_17 NBIT_B[0]_18 NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21
+  NBIT_B[0]_22 NBIT_B[0]_23 NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26
+  NBIT_B[0]_27 NBIT_B[0]_28 NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31
+  NBIT_B[0]_32 NBIT_B[0]_33 NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36
+  NBIT_B[0]_37 NBIT_B[0]_38 NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41
+  NBIT_B[0]_42 NBIT_B[0]_43 NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46
+  NBIT_B[0]_47 NBIT_B[0]_48 NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51
+  NBIT_B[0]_52 NBIT_B[0]_53 NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56
+  NBIT_B[0]_57 NBIT_B[0]_58 NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61
+  NBIT_B[0]_62 NBIT_B[0]_63 NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3
+  NBIT_B[1]_4 NBIT_B[1]_5 NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9
+  NBIT_B[1]_10 NBIT_B[1]_11 NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14
+  NBIT_B[1]_15 NBIT_B[1]_16 NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19
+  NBIT_B[1]_20 NBIT_B[1]_21 NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24
+  NBIT_B[1]_25 NBIT_B[1]_26 NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29
+  NBIT_B[1]_30 NBIT_B[1]_31 NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34
+  NBIT_B[1]_35 NBIT_B[1]_36 NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39
+  NBIT_B[1]_40 NBIT_B[1]_41 NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44
+  NBIT_B[1]_45 NBIT_B[1]_46 NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49
+  NBIT_B[1]_50 NBIT_B[1]_51 NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54
+  NBIT_B[1]_55 NBIT_B[1]_56 NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59
+  NBIT_B[1]_60 NBIT_B[1]_61 NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1
+  NBIT_B[2]_2 NBIT_B[2]_3 NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7
+  NBIT_B[2]_8 NBIT_B[2]_9 NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13
+  NBIT_B[2]_14 NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18
+  NBIT_B[2]_19 NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23
+  NBIT_B[2]_24 NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28
+  NBIT_B[2]_29 NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33
+  NBIT_B[2]_34 NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38
+  NBIT_B[2]_39 NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43
+  NBIT_B[2]_44 NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48
+  NBIT_B[2]_49 NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53
+  NBIT_B[2]_54 NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58
+  NBIT_B[2]_59 NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63
+  NBIT_B[3]_0 NBIT_B[3]_1 NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5
+  NBIT_B[3]_6 NBIT_B[3]_7 NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11
+  NBIT_B[3]_12 NBIT_B[3]_13 NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16
+  NBIT_B[3]_17 NBIT_B[3]_18 NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21
+  NBIT_B[3]_22 NBIT_B[3]_23 NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26
+  NBIT_B[3]_27 NBIT_B[3]_28 NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31
+  NBIT_B[3]_32 NBIT_B[3]_33 NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36
+  NBIT_B[3]_37 NBIT_B[3]_38 NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41
+  NBIT_B[3]_42 NBIT_B[3]_43 NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46
+  NBIT_B[3]_47 NBIT_B[3]_48 NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51
+  NBIT_B[3]_52 NBIT_B[3]_53 NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56
+  NBIT_B[3]_57 NBIT_B[3]_58 NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61
+  NBIT_B[3]_62 NBIT_B[3]_63 NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A
+  NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2
+  NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8
+  NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14
+  NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20
+  NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26
+  NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32
+  NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38
+  NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44
+  NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50
+  NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56
+  NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62
+  NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4
+  NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10
+  NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16
+  NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22
+  NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28
+  NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34
+  NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40
+  NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46
+  NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52
+  NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58
+  NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A
+  NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0]
+  RET_SHR_DEC1B[1] RE_A RE_B VDDC VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDPE_0 VDDPE_1
+  VDDPE_2 VDDPE_3 VDDPE_4 VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10
+  VDDPE_11 VDDPE_12 VDDPE_13 VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18
+  VDDPE_19 VDDPE_20 VDDPE_21 VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26
+  VDDPE_27 VDDPE_28 VDDPE_29 VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34
+  VDDPE_35 VDDPE_36 VDDPE_37 VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42
+  VDDPE_43 VDDPE_44 VDDPE_45 VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50
+  VDDPE_51 VDDPE_52 VDDPE_53 VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58
+  VDDPE_59 VDDPE_60 VDDPE_61 VDDPE_62 VDDPE_63 VDDPE_64 VNWP_0 VNWP_1 VNWP_2
+  VNWP_3 VPW VSSE_0 VSSE_1 VSSE_2 VSSE_3 WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256ICAPCCIO0: 3080 flat devices **
XICAPCCIO0 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1]
+  BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3 BIT_A[0]_4 BIT_A[0]_5
+  BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9 BIT_A[0]_10 BIT_A[0]_11
+  BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15 BIT_A[0]_16 BIT_A[0]_17
+  BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21 BIT_A[0]_22 BIT_A[0]_23
+  BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27 BIT_A[0]_28 BIT_A[0]_29
+  BIT_A[0]_30 BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34 BIT_A[0]_35
+  BIT_A[0]_36 BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40 BIT_A[0]_41
+  BIT_A[0]_42 BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46 BIT_A[0]_47
+  BIT_A[0]_48 BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52 BIT_A[0]_53
+  BIT_A[0]_54 BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58 BIT_A[0]_59
+  BIT_A[0]_60 BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_0 BIT_A[1]_1
+  BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6 BIT_A[1]_7
+  BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12 BIT_A[1]_13
+  BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18 BIT_A[1]_19
+  BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24 BIT_A[1]_25
+  BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30 BIT_A[1]_31
+  BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35 BIT_A[1]_36 BIT_A[1]_37
+  BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41 BIT_A[1]_42 BIT_A[1]_43
+  BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47 BIT_A[1]_48 BIT_A[1]_49
+  BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53 BIT_A[1]_54 BIT_A[1]_55
+  BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59 BIT_A[1]_60 BIT_A[1]_61
+  BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2 BIT_A[2]_3
+  BIT_A[2]_4 BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8 BIT_A[2]_9
+  BIT_A[2]_10 BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14 BIT_A[2]_15
+  BIT_A[2]_16 BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20 BIT_A[2]_21
+  BIT_A[2]_22 BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26 BIT_A[2]_27
+  BIT_A[2]_28 BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31 BIT_A[2]_32 BIT_A[2]_33
+  BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38 BIT_A[2]_39
+  BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44 BIT_A[2]_45
+  BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50 BIT_A[2]_51
+  BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56 BIT_A[2]_57
+  BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62 BIT_A[2]_63
+  BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3 BIT_A[3]_4 BIT_A[3]_5
+  BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9 BIT_A[3]_10 BIT_A[3]_11
+  BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15 BIT_A[3]_16 BIT_A[3]_17
+  BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21 BIT_A[3]_22 BIT_A[3]_23
+  BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27 BIT_A[3]_28 BIT_A[3]_29
+  BIT_A[3]_30 BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34 BIT_A[3]_35
+  BIT_A[3]_36 BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40 BIT_A[3]_41
+  BIT_A[3]_42 BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46 BIT_A[3]_47
+  BIT_A[3]_48 BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52 BIT_A[3]_53
+  BIT_A[3]_54 BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58 BIT_A[3]_59
+  BIT_A[3]_60 BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_0 BIT_B[0]_1
+  BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6 BIT_B[0]_7
+  BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12 BIT_B[0]_13
+  BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18 BIT_B[0]_19
+  BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24 BIT_B[0]_25
+  BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30 BIT_B[0]_31
+  BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35 BIT_B[0]_36 BIT_B[0]_37
+  BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41 BIT_B[0]_42 BIT_B[0]_43
+  BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47 BIT_B[0]_48 BIT_B[0]_49
+  BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53 BIT_B[0]_54 BIT_B[0]_55
+  BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59 BIT_B[0]_60 BIT_B[0]_61
+  BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2 BIT_B[1]_3
+  BIT_B[1]_4 BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8 BIT_B[1]_9
+  BIT_B[1]_10 BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14 BIT_B[1]_15
+  BIT_B[1]_16 BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20 BIT_B[1]_21
+  BIT_B[1]_22 BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26 BIT_B[1]_27
+  BIT_B[1]_28 BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31 BIT_B[1]_32 BIT_B[1]_33
+  BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38 BIT_B[1]_39
+  BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44 BIT_B[1]_45
+  BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50 BIT_B[1]_51
+  BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56 BIT_B[1]_57
+  BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62 BIT_B[1]_63
+  BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3 BIT_B[2]_4 BIT_B[2]_5
+  BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9 BIT_B[2]_10 BIT_B[2]_11
+  BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15 BIT_B[2]_16 BIT_B[2]_17
+  BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21 BIT_B[2]_22 BIT_B[2]_23
+  BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27 BIT_B[2]_28 BIT_B[2]_29
+  BIT_B[2]_30 BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34 BIT_B[2]_35
+  BIT_B[2]_36 BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40 BIT_B[2]_41
+  BIT_B[2]_42 BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46 BIT_B[2]_47
+  BIT_B[2]_48 BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52 BIT_B[2]_53
+  BIT_B[2]_54 BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58 BIT_B[2]_59
+  BIT_B[2]_60 BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_0 BIT_B[3]_1
+  BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6 BIT_B[3]_7
+  BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12 BIT_B[3]_13
+  BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18 BIT_B[3]_19
+  BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24 BIT_B[3]_25
+  BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30 BIT_B[3]_31
+  BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35 BIT_B[3]_36 BIT_B[3]_37
+  BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41 BIT_B[3]_42 BIT_B[3]_43
+  BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47 BIT_B[3]_48 BIT_B[3]_49
+  BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53 BIT_B[3]_54 BIT_B[3]_55
+  BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59 BIT_B[3]_60 BIT_B[3]_61
+  BIT_B[3]_62 BIT_B[3]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1
+  DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7
+  DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13
+  DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19
+  DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25
+  DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31
+  DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37
+  DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43
+  DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49
+  DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55
+  DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61
+  DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3
+  DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9
+  DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15
+  DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21
+  DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27
+  DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33
+  DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39
+  DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45
+  DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51
+  DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57
+  DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63
+  DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7
+  GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15
+  GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23
+  GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31
+  GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39
+  GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47
+  GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55
+  GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63
+  GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8
+  GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16
+  GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24
+  GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32
+  GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40
+  GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48
+  GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56
+  GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 LOG0_DBL_A
+  LOG0_DBL_B NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2 NBIT_A[0]_3 NBIT_A[0]_4
+  NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8 NBIT_A[0]_9 NBIT_A[0]_10
+  NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13 NBIT_A[0]_14 NBIT_A[0]_15
+  NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18 NBIT_A[0]_19 NBIT_A[0]_20
+  NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23 NBIT_A[0]_24 NBIT_A[0]_25
+  NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28 NBIT_A[0]_29 NBIT_A[0]_30
+  NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33 NBIT_A[0]_34 NBIT_A[0]_35
+  NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38 NBIT_A[0]_39 NBIT_A[0]_40
+  NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43 NBIT_A[0]_44 NBIT_A[0]_45
+  NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48 NBIT_A[0]_49 NBIT_A[0]_50
+  NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53 NBIT_A[0]_54 NBIT_A[0]_55
+  NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58 NBIT_A[0]_59 NBIT_A[0]_60
+  NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63 NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2
+  NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5 NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8
+  NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11 NBIT_A[1]_12 NBIT_A[1]_13
+  NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16 NBIT_A[1]_17 NBIT_A[1]_18
+  NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21 NBIT_A[1]_22 NBIT_A[1]_23
+  NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26 NBIT_A[1]_27 NBIT_A[1]_28
+  NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31 NBIT_A[1]_32 NBIT_A[1]_33
+  NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36 NBIT_A[1]_37 NBIT_A[1]_38
+  NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41 NBIT_A[1]_42 NBIT_A[1]_43
+  NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46 NBIT_A[1]_47 NBIT_A[1]_48
+  NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51 NBIT_A[1]_52 NBIT_A[1]_53
+  NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56 NBIT_A[1]_57 NBIT_A[1]_58
+  NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61 NBIT_A[1]_62 NBIT_A[1]_63
+  NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3 NBIT_A[2]_4 NBIT_A[2]_5
+  NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9 NBIT_A[2]_10 NBIT_A[2]_11
+  NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14 NBIT_A[2]_15 NBIT_A[2]_16
+  NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19 NBIT_A[2]_20 NBIT_A[2]_21
+  NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24 NBIT_A[2]_25 NBIT_A[2]_26
+  NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29 NBIT_A[2]_30 NBIT_A[2]_31
+  NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34 NBIT_A[2]_35 NBIT_A[2]_36
+  NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39 NBIT_A[2]_40 NBIT_A[2]_41
+  NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44 NBIT_A[2]_45 NBIT_A[2]_46
+  NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49 NBIT_A[2]_50 NBIT_A[2]_51
+  NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54 NBIT_A[2]_55 NBIT_A[2]_56
+  NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59 NBIT_A[2]_60 NBIT_A[2]_61
+  NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1 NBIT_A[3]_2 NBIT_A[3]_3
+  NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7 NBIT_A[3]_8 NBIT_A[3]_9
+  NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13 NBIT_A[3]_14
+  NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18 NBIT_A[3]_19
+  NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23 NBIT_A[3]_24
+  NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28 NBIT_A[3]_29
+  NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33 NBIT_A[3]_34
+  NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38 NBIT_A[3]_39
+  NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43 NBIT_A[3]_44
+  NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48 NBIT_A[3]_49
+  NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53 NBIT_A[3]_54
+  NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58 NBIT_A[3]_59
+  NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63 NBIT_B[0]_0 NBIT_B[0]_1
+  NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5 NBIT_B[0]_6 NBIT_B[0]_7
+  NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11 NBIT_B[0]_12 NBIT_B[0]_13
+  NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16 NBIT_B[0]_17 NBIT_B[0]_18
+  NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21 NBIT_B[0]_22 NBIT_B[0]_23
+  NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26 NBIT_B[0]_27 NBIT_B[0]_28
+  NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31 NBIT_B[0]_32 NBIT_B[0]_33
+  NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36 NBIT_B[0]_37 NBIT_B[0]_38
+  NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41 NBIT_B[0]_42 NBIT_B[0]_43
+  NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46 NBIT_B[0]_47 NBIT_B[0]_48
+  NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51 NBIT_B[0]_52 NBIT_B[0]_53
+  NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56 NBIT_B[0]_57 NBIT_B[0]_58
+  NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61 NBIT_B[0]_62 NBIT_B[0]_63
+  NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3 NBIT_B[1]_4 NBIT_B[1]_5
+  NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9 NBIT_B[1]_10 NBIT_B[1]_11
+  NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14 NBIT_B[1]_15 NBIT_B[1]_16
+  NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19 NBIT_B[1]_20 NBIT_B[1]_21
+  NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24 NBIT_B[1]_25 NBIT_B[1]_26
+  NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29 NBIT_B[1]_30 NBIT_B[1]_31
+  NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34 NBIT_B[1]_35 NBIT_B[1]_36
+  NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39 NBIT_B[1]_40 NBIT_B[1]_41
+  NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44 NBIT_B[1]_45 NBIT_B[1]_46
+  NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49 NBIT_B[1]_50 NBIT_B[1]_51
+  NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54 NBIT_B[1]_55 NBIT_B[1]_56
+  NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59 NBIT_B[1]_60 NBIT_B[1]_61
+  NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1 NBIT_B[2]_2 NBIT_B[2]_3
+  NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7 NBIT_B[2]_8 NBIT_B[2]_9
+  NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13 NBIT_B[2]_14
+  NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18 NBIT_B[2]_19
+  NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23 NBIT_B[2]_24
+  NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28 NBIT_B[2]_29
+  NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33 NBIT_B[2]_34
+  NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38 NBIT_B[2]_39
+  NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43 NBIT_B[2]_44
+  NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48 NBIT_B[2]_49
+  NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53 NBIT_B[2]_54
+  NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58 NBIT_B[2]_59
+  NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63 NBIT_B[3]_0 NBIT_B[3]_1
+  NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5 NBIT_B[3]_6 NBIT_B[3]_7
+  NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11 NBIT_B[3]_12 NBIT_B[3]_13
+  NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16 NBIT_B[3]_17 NBIT_B[3]_18
+  NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21 NBIT_B[3]_22 NBIT_B[3]_23
+  NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26 NBIT_B[3]_27 NBIT_B[3]_28
+  NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31 NBIT_B[3]_32 NBIT_B[3]_33
+  NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36 NBIT_B[3]_37 NBIT_B[3]_38
+  NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41 NBIT_B[3]_42 NBIT_B[3]_43
+  NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46 NBIT_B[3]_47 NBIT_B[3]_48
+  NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51 NBIT_B[3]_52 NBIT_B[3]_53
+  NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56 NBIT_B[3]_57 NBIT_B[3]_58
+  NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61 NBIT_B[3]_62 NBIT_B[3]_63 NC_RET_ACT
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5
+  NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11
+  NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17
+  NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23
+  NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29
+  NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35
+  NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41
+  NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47
+  NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53
+  NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59
+  NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1
+  NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7
+  NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13
+  NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19
+  NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25
+  NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31
+  NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37
+  NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43
+  NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49
+  NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55
+  NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61
+  NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1]
+  RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A
+  RE_B VDDCA1 VDDCA2 VDDCB1 VDDCB2 VDDPE_0 VDDPE_1 VDDPE_2 VDDPE_3 VDDPE_4
+  VDDPE_5 VDDPE_6 VDDPE_7 VDDPE_8 VDDPE_9 VDDPE_10 VDDPE_11 VDDPE_12 VDDPE_13
+  VDDPE_14 VDDPE_15 VDDPE_16 VDDPE_17 VDDPE_18 VDDPE_19 VDDPE_20 VDDPE_21
+  VDDPE_22 VDDPE_23 VDDPE_24 VDDPE_25 VDDPE_26 VDDPE_27 VDDPE_28 VDDPE_29
+  VDDPE_30 VDDPE_31 VDDPE_32 VDDPE_33 VDDPE_34 VDDPE_35 VDDPE_36 VDDPE_37
+  VDDPE_38 VDDPE_39 VDDPE_40 VDDPE_41 VDDPE_42 VDDPE_43 VDDPE_44 VDDPE_45
+  VDDPE_46 VDDPE_47 VDDPE_48 VDDPE_49 VDDPE_50 VDDPE_51 VDDPE_52 VDDPE_53
+  VDDPE_54 VDDPE_55 VDDPE_56 VDDPE_57 VDDPE_58 VDDPE_59 VDDPE_60 VDDPE_61
+  VDDPE_62 VDDPE_63 VDDPE_64 VDDC VNWP_0 VNWP_1 VNWP_2 VNWP_3 VPW VSSE_0
+  VSSE_1 VSSE_2 VSSE_3 WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
+  SRAMdpw64d256CCIIO32320
.ENDS SRAMdpw64d256ICAPCCIO0
****
.SUBCKT SRAMdpw64d256EDGE_CM NACT_B NACT_T NC_NDSA_TP_A NC_NDSA_TP_B
+  NC_NRSEL_A[0] NC_NRSEL_A[1] NC_NRSEL_A[2] NC_NRSEL_A[3] NC_NRSEL_B[0]
+  NC_NRSEL_B[1] NC_NRSEL_B[2] NC_NRSEL_B[3] NC_NWSEL_A[0] NC_NWSEL_A[1]
+  NC_NWSEL_A[2] NC_NWSEL_A[3] NC_NWSEL_B[0] NC_NWSEL_B[1] NC_NWSEL_B[2]
+  NC_NWSEL_B[3] NC_PCH_BL_B_A NC_PCH_BL_B_B NC_RDA_OVRDB NC_RDB_OVRDB
+  NC_SA_TP_A NC_SA_TP_B NWCLK_WT_A NWCLK_WT_B SA_TIELO VDDPE VNWC VNWP VPW
+  VSSE
** SRAMdpw64d256EDGE_CM: 2 flat devices **
X_MXN0 VSSE SA_TIELO VSSE VPW N11LL_CKT W=0.28U L=0.08U
X_MXN16 VSSE SA_TIELO VSSE VPW N11LL_CKT W=0.14U L=0.04U
.ENDS SRAMdpw64d256EDGE_CM
****
.SUBCKT SRAMdpw64d256CMUXSA BLB_A[0] BLB_A[1] BLB_A[2] BLB_A[3] BLB_B[0]
+  BLB_B[1] BLB_B[2] BLB_B[3] DATAIN_A DATAIN_B GDL_A GDL_B NACT_B NACT_FDBK_B
+  NACT_FDBK_T NACT_T NBLB_A[0] NBLB_A[1] NBLB_A[2] NBLB_A[3] NBLB_B[0]
+  NBLB_B[1] NBLB_B[2] NBLB_B[3] NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1]
+  NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3]
+  NWCLK_WT_A NWCLK_WT_B NWGSEL_A NWGSEL_B NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE VDDPE VNWC
+  VNWP VPW VSSE
** SRAMdpw64d256CMUXSA: 310 flat devices **
X_MIblmuxb.MXN1_0 BLB_A[0] OVRDB_A[0] DI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN1_1 BLB_A[1] OVRDB_A[1] DI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN1_2 BLB_A[2] OVRDB_A[2] DI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN1_3 BLB_A[3] OVRDB_A[3] DI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN2_0 NBLB_A[0] OVRDB_A[0] NDI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN2_1 NBLB_A[1] OVRDB_A[1] NDI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN2_2 NBLB_A[2] OVRDB_A[2] NDI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN2_3 NBLB_A[3] OVRDB_A[3] NDI_B VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN3_0 NBLB_B[0] OVRDB_B[0] NDI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN3_1 NBLB_B[1] OVRDB_B[1] NDI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN3_2 NBLB_B[2] OVRDB_B[2] NDI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN3_3 NBLB_B[3] OVRDB_B[3] NDI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN4_0 BLB_B[0] OVRDB_B[0] DI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN4_1 BLB_B[1] OVRDB_B[1] DI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN4_2 BLB_B[2] OVRDB_B[2] DI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIblmuxb.MXN4_3 BLB_B[3] OVRDB_B[3] DI_A VPW N11LL_CKT W=0.57U L=0.04U
X_MIcolmuxa.Irw_b.I1.MXNA1 ICOLMUXA.IRW_B.RD_OVRD_N RDB_OVRDB VSSE VPW
+  N11LL_CKT W=0.29U L=0.04U
X_MIcolmuxa.Irw_b.I1.MXPA1 ICOLMUXA.IRW_B.RD_OVRD_N RDB_OVRDB VDDPE VNWP
+  P11LL_CKT W=0.57U L=0.04U
X_MIcolmuxa.Irw_b.I7.MXNA1 ICOLMUXA.IRW_B.PCH_N PCH_BL_B_A VSSE VPW N11LL_CKT
+  W=0.305U L=0.04U
X_MIcolmuxa.Irw_b.I7.MXPA1 ICOLMUXA.IRW_B.PCH_N PCH_BL_B_A VDDPE VNWP
+  P11LL_CKT W=1.18U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I10.MXNA1
+  ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_0.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I10.MXPA1
+  ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_0.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I8.MXNA1 ICOLMUXA.IRW_B.IRW_0.WSEL
+  NWSEL_A[0] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I8.MXNA2 ICOLMUXA.IRW_B.IRW_0.WSEL NWGSEL_A
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I8.MXPA1 ICOLMUXA.IRW_B.IRW_0.WSEL
+  NWSEL_A[0] ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I8.MXPA2
+  ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.I8.P1 NWGSEL_A VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I9.MXNA1 OVRDB_B[0]
+  ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I9.MXNA2 OVRDB_B[0] ICOLMUXA.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I9.MXPA1 OVRDB_B[0]
+  ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwgatedp.I9.MXPA2
+  ICOLMUXA.IRW_B.IRW_0.IRWGATEDP.I9.P1 ICOLMUXA.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXN0 NBLB_A[0] ICOLMUXA.IRW_B.IRW_0.WSEL
+  NDI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXN1 BLB_A[0] ICOLMUXA.IRW_B.IRW_0.WSEL
+  DI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP1 NBLB_A[0] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP10
+  ICOLMUXA.IRW_B.IRW_0.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP3 ICOLMUXA.NDLB NRSEL_A[0] NBLB_A[0]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP4 ICOLMUXA.DLB NRSEL_A[0] BLB_A[0]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP5 NBLB_A[0] BLB_A[0]
+  ICOLMUXA.IRW_B.IRW_0.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP7 BLB_A[0] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP8 NBLB_A[0] ICOLMUXA.IRW_B.PCH_N
+  BLB_A[0] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_0.Irwiso.Icmux.MXP9 BLB_A[0] NBLB_A[0]
+  ICOLMUXA.IRW_B.IRW_0.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I10.MXNA1
+  ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_1.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I10.MXPA1
+  ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_1.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I8.MXNA1 ICOLMUXA.IRW_B.IRW_1.WSEL
+  NWSEL_A[1] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I8.MXNA2 ICOLMUXA.IRW_B.IRW_1.WSEL NWGSEL_A
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I8.MXPA1 ICOLMUXA.IRW_B.IRW_1.WSEL
+  NWSEL_A[1] ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I8.MXPA2
+  ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.I8.P1 NWGSEL_A VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I9.MXNA1 OVRDB_B[1]
+  ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I9.MXNA2 OVRDB_B[1] ICOLMUXA.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I9.MXPA1 OVRDB_B[1]
+  ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwgatedp.I9.MXPA2
+  ICOLMUXA.IRW_B.IRW_1.IRWGATEDP.I9.P1 ICOLMUXA.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXN0 NBLB_A[1] ICOLMUXA.IRW_B.IRW_1.WSEL
+  NDI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXN1 BLB_A[1] ICOLMUXA.IRW_B.IRW_1.WSEL
+  DI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP1 NBLB_A[1] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP10
+  ICOLMUXA.IRW_B.IRW_1.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP3 ICOLMUXA.NDLB NRSEL_A[1] NBLB_A[1]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP4 ICOLMUXA.DLB NRSEL_A[1] BLB_A[1]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP5 NBLB_A[1] BLB_A[1]
+  ICOLMUXA.IRW_B.IRW_1.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP7 BLB_A[1] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP8 NBLB_A[1] ICOLMUXA.IRW_B.PCH_N
+  BLB_A[1] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_1.Irwiso.Icmux.MXP9 BLB_A[1] NBLB_A[1]
+  ICOLMUXA.IRW_B.IRW_1.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I10.MXNA1
+  ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_2.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I10.MXPA1
+  ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_2.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I8.MXNA1 ICOLMUXA.IRW_B.IRW_2.WSEL
+  NWSEL_A[2] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I8.MXNA2 ICOLMUXA.IRW_B.IRW_2.WSEL NWGSEL_A
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I8.MXPA1 ICOLMUXA.IRW_B.IRW_2.WSEL
+  NWSEL_A[2] ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I8.MXPA2
+  ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.I8.P1 NWGSEL_A VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I9.MXNA1 OVRDB_B[2]
+  ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I9.MXNA2 OVRDB_B[2] ICOLMUXA.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I9.MXPA1 OVRDB_B[2]
+  ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwgatedp.I9.MXPA2
+  ICOLMUXA.IRW_B.IRW_2.IRWGATEDP.I9.P1 ICOLMUXA.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXN0 NBLB_A[2] ICOLMUXA.IRW_B.IRW_2.WSEL
+  NDI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXN1 BLB_A[2] ICOLMUXA.IRW_B.IRW_2.WSEL
+  DI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP1 NBLB_A[2] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP10
+  ICOLMUXA.IRW_B.IRW_2.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP3 ICOLMUXA.NDLB NRSEL_A[2] NBLB_A[2]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP4 ICOLMUXA.DLB NRSEL_A[2] BLB_A[2]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP5 NBLB_A[2] BLB_A[2]
+  ICOLMUXA.IRW_B.IRW_2.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP7 BLB_A[2] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP8 NBLB_A[2] ICOLMUXA.IRW_B.PCH_N
+  BLB_A[2] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_2.Irwiso.Icmux.MXP9 BLB_A[2] NBLB_A[2]
+  ICOLMUXA.IRW_B.IRW_2.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I10.MXNA1
+  ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_3.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I10.MXPA1
+  ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_3.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I8.MXNA1 ICOLMUXA.IRW_B.IRW_3.WSEL
+  NWSEL_A[3] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I8.MXNA2 ICOLMUXA.IRW_B.IRW_3.WSEL NWGSEL_A
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I8.MXPA1 ICOLMUXA.IRW_B.IRW_3.WSEL
+  NWSEL_A[3] ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I8.MXPA2
+  ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.I8.P1 NWGSEL_A VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I9.MXNA1 OVRDB_B[3]
+  ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I9.MXNA2 OVRDB_B[3] ICOLMUXA.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I9.MXPA1 OVRDB_B[3]
+  ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.NWSE ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwgatedp.I9.MXPA2
+  ICOLMUXA.IRW_B.IRW_3.IRWGATEDP.I9.P1 ICOLMUXA.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXN0 NBLB_A[3] ICOLMUXA.IRW_B.IRW_3.WSEL
+  NDI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXN1 BLB_A[3] ICOLMUXA.IRW_B.IRW_3.WSEL
+  DI_A VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP1 NBLB_A[3] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP10
+  ICOLMUXA.IRW_B.IRW_3.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP3 ICOLMUXA.NDLB NRSEL_A[3] NBLB_A[3]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP4 ICOLMUXA.DLB NRSEL_A[3] BLB_A[3]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP5 NBLB_A[3] BLB_A[3]
+  ICOLMUXA.IRW_B.IRW_3.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP7 BLB_A[3] ICOLMUXA.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP8 NBLB_A[3] ICOLMUXA.IRW_B.PCH_N
+  BLB_A[3] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Irw_b.Irw_3.Irwiso.Icmux.MXP9 BLB_A[3] NBLB_A[3]
+  ICOLMUXA.IRW_B.IRW_3.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Irw_b.MXP13 ICOLMUXA.NDLB ICOLMUXA.IRW_B.PCH_N VDDPE VNWC
+  P11LL_CKT W=0.175U L=0.04U
X_MIcolmuxa.Irw_b.MXP14 ICOLMUXA.DLB ICOLMUXA.IRW_B.PCH_N VDDPE VNWC P11LL_CKT
+  W=0.175U L=0.04U
X_MIcolmuxa.Isa.I12.MXNA1 ICOLMUXA.ISA.SAE ICOLMUXA.ISA.SA_TP_N VSSE VPW
+  N11LL_CKT W=0.25U L=0.04U
X_MIcolmuxa.Isa.I12.MXNA2 ICOLMUXA.ISA.SAE ICOLMUXA.ISA.SA_DLY_TP VSSE VPW
+  N11LL_CKT W=0.25U L=0.04U
X_MIcolmuxa.Isa.I12.MXPA1 ICOLMUXA.ISA.SAE ICOLMUXA.ISA.SA_TP_N
+  ICOLMUXA.ISA.I12.P1 VNWP P11LL_CKT W=0.855U L=0.04U
X_MIcolmuxa.Isa.I12.MXPA2 ICOLMUXA.ISA.I12.P1 ICOLMUXA.ISA.SA_DLY_TP VDDPE
+  VNWP P11LL_CKT W=0.855U L=0.04U
X_MIcolmuxa.Isa.I23.MXNA1 ICOLMUXA.ISA.BSA_DLY_TP_N ICOLMUXA.ISA.SA_DLY_TP
+  VSSE VPW N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxa.Isa.I23.MXPA1 ICOLMUXA.ISA.BSA_DLY_TP_N ICOLMUXA.ISA.SA_DLY_TP
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxa.Isa.I24.MXNA1 ICOLMUXA.ISA.SA_PRE ICOLMUXA.ISA.SA_TP_N VSSE VPW
+  N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxa.Isa.I24.MXNA2 ICOLMUXA.ISA.SA_PRE ICOLMUXA.ISA.BSA_DLY_TP_N VSSE
+  VPW N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxa.Isa.I24.MXPA1 ICOLMUXA.ISA.SA_PRE ICOLMUXA.ISA.SA_TP_N
+  ICOLMUXA.ISA.I24.P1 VNWP P11LL_CKT W=0.2U L=0.04U
X_MIcolmuxa.Isa.I24.MXPA2 ICOLMUXA.ISA.I24.P1 ICOLMUXA.ISA.BSA_DLY_TP_N VDDPE
+  VNWP P11LL_CKT W=0.2U L=0.04U
X_MIcolmuxa.Isa.I25.MXNA1 ICOLMUXA.ISA.SA_PRE_N ICOLMUXA.ISA.SA_PRE VSSE VPW
+  N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxa.Isa.I25.MXPA1 ICOLMUXA.ISA.SA_PRE_N ICOLMUXA.ISA.SA_PRE VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxa.Isa.I27.MXNA1 ICOLMUXA.ISA.SA_TP_N SA_TP_A VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_MIcolmuxa.Isa.I27.MXPA1 ICOLMUXA.ISA.SA_TP_N SA_TP_A VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_MIcolmuxa.Isa.I28.MXNA1 ICOLMUXA.ISA.SA_DLY_TP NDSA_TP_A VSSE VPW N11LL_CKT
+  W=0.23U L=0.04U
X_MIcolmuxa.Isa.I28.MXPA1 ICOLMUXA.ISA.SA_DLY_TP NDSA_TP_A VDDPE VNWP
+  P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I62.MXNA1 GDL_A ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT
+  VSSE VPW N11LL_CKT W=1.86U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I62.MXPA1 GDL_A ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT
+  VDDPE VNWP P11LL_CKT W=2.18U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I68.MXNA1 ICOLMUXA.ISA.ISALAT.ISLAT.WCLK_WT
+  NWCLK_WT_A VSSE VPW N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I68.MXPA1 ICOLMUXA.ISA.ISALAT.ISLAT.WCLK_WT
+  NWCLK_WT_A VDDPE VNWP P11LL_CKT W=0.3U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I69.MXNA1 ICOLMUXA.ISA.ISALAT.ISLAT.I69.N1 NDI_A
+  VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I69.MXNOE ICOLMUXA.ISA.ISALAT.ISLAT.NSD_LAT
+  ICOLMUXA.ISA.ISALAT.ISLAT.WCLK_WT ICOLMUXA.ISA.ISALAT.ISLAT.I69.N1 VPW
+  N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I69.MXPA1 ICOLMUXA.ISA.ISALAT.ISLAT.I69.P1 NDI_A
+  VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I69.MXPOEN ICOLMUXA.ISA.ISALAT.ISLAT.NSD_LAT
+  NWCLK_WT_A ICOLMUXA.ISA.ISALAT.ISLAT.I69.P1 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I70.MXNA1 ICOLMUXA.ISA.ISALAT.ISLAT.I70.N1
+  ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I70.MXNOE ICOLMUXA.ISA.ISALAT.ISLAT.NSD_LAT
+  NWCLK_WT_A ICOLMUXA.ISA.ISALAT.ISLAT.I70.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I70.MXPA1 ICOLMUXA.ISA.ISALAT.ISLAT.I70.P1
+  ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I70.MXPOEN ICOLMUXA.ISA.ISALAT.ISLAT.NSD_LAT
+  ICOLMUXA.ISA.ISALAT.ISLAT.WCLK_WT ICOLMUXA.ISA.ISALAT.ISLAT.I70.P1 VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I82.MXNA1 ICOLMUXA.ISA.ISALAT.ISLAT.NLAT_E
+  ICOLMUXA.ISA.SAE VSSE VPW N11LL_CKT W=0.135U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.I82.MXPA1 ICOLMUXA.ISA.ISALAT.ISLAT.NLAT_E
+  ICOLMUXA.ISA.SAE VDDPE VNWP P11LL_CKT W=0.27U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MXN8 ICOLMUXA.ISA.ISALAT.ISLAT.N1B
+  ICOLMUXA.ISA.ISALAT.ISLAT.NSD_LAT VSSE VPW N11LL_CKT W=0.5U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MXN9 ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXA.ISA.ISALAT.ISLAT.NLAT_E ICOLMUXA.ISA.ISALAT.ISLAT.N1B VPW
+  N11LL_CKT W=0.5U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MXP6 ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXA.ISA.SAE ICOLMUXA.ISA.ISALAT.ISLAT.P1B VNWP P11LL_CKT W=0.8U
+  L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MXP7 ICOLMUXA.ISA.ISALAT.ISLAT.P1B
+  ICOLMUXA.ISA.ISALAT.ISLAT.NSD_LAT VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MXPs ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXA.ISA.SD ICOLMUXA.ISA.ISALAT.ISLAT.P1A VNWP P11LL_CKT W=1.03U
+  L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MX_ndmy ICOLMUXA.ISA.ISALAT.ISLAT.NSD_DUM
+  ICOLMUXA.ISA.NSD ICOLMUXA.ISA.ISALAT.ISLAT.N1A VPW N11LL_CKT W=0.57U
+  L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MX_nlat ICOLMUXA.ISA.ISALAT.ISLAT.N1A
+  ICOLMUXA.ISA.SAE VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MX_pdmy ICOLMUXA.ISA.ISALAT.ISLAT.NSD_DUM
+  ICOLMUXA.ISA.NSD ICOLMUXA.ISA.ISALAT.ISLAT.P1A VNWP P11LL_CKT W=1.03U
+  L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MX_pnsae ICOLMUXA.ISA.ISALAT.ISLAT.P1A
+  ICOLMUXA.ISA.ISALAT.ISLAT.NLAT_E VDDPE VNWP P11LL_CKT W=1.03U L=0.04U
X_MIcolmuxa.Isa.Isalat.Islat.MX_sd_n ICOLMUXA.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXA.ISA.SD ICOLMUXA.ISA.ISALAT.ISLAT.N1A VPW N11LL_CKT W=0.57U L=0.04U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXN17 ICOLMUXA.ISA.NSD ICOLMUXA.ISA.SD
+  ICOLMUXA.ISA.ISAMP.NET18 VPW N11LL_CKT W=2.4U L=0.08U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXN18 ICOLMUXA.ISA.ISAMP.NET18
+  ICOLMUXA.ISA.SAE VSSE VPW N11LL_CKT W=1.11U L=0.04U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXN19 ICOLMUXA.ISA.SD ICOLMUXA.ISA.NSD
+  ICOLMUXA.ISA.ISAMP.NET18 VPW N11LL_CKT W=2.4U L=0.08U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXP24 ICOLMUXA.ISA.NSD ICOLMUXA.ISA.SA_PRE_N
+  VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXP25 ICOLMUXA.ISA.NSD ICOLMUXA.ISA.SA_PRE_N
+  ICOLMUXA.ISA.SD VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXP26 ICOLMUXA.ISA.SD ICOLMUXA.ISA.SA_PRE_N
+  VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXP27 ICOLMUXA.ISA.NSD ICOLMUXA.ISA.SD VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxa.Isa.Isamp.Isenseamp.MXP28 ICOLMUXA.ISA.SD ICOLMUXA.ISA.NSD VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxa.Isa.MXN13 NDI_A DATAIN_A VSSE VPW N11LL_CKT W=2.46U L=0.04U
X_MIcolmuxa.Isa.MXN14 DI_A NDI_A VSSE VPW N11LL_CKT W=2.46U L=0.04U
X_MIcolmuxa.Isa.MXN16 ICOLMUXA.ISA.ISO_B ICOLMUXA.ISA.SA_TP_N VSSE VPW
+  N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxa.Isa.MXP17 NDI_A DATAIN_A RET_SHR VNWP P11LL_CKT W=2.32U L=0.04U
X_MIcolmuxa.Isa.MXP18 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MIcolmuxa.Isa.MXP19 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MIcolmuxa.Isa.MXP20 DI_A NDI_A RET_SHR VNWP P11LL_CKT W=2.32U L=0.04U
X_MIcolmuxa.Isa.MXP21 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.505U L=0.04U
X_MIcolmuxa.Isa.MXP22 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.505U L=0.04U
X_MIcolmuxa.Isa.MXP25 ICOLMUXA.ISA.ISO_B ICOLMUXA.ISA.SA_TP_N
+  ICOLMUXA.ISA.NET109 VNWP P11LL_CKT W=0.26U L=0.04U
X_MIcolmuxa.Isa.MXP26 ICOLMUXA.ISA.NET109 ICOLMUXA.ISA.SA_TP_N VDDPE VNWP
+  P11LL_CKT W=0.26U L=0.04U
X_MIcolmuxa.Isa.MXP8 ICOLMUXA.ISA.SD ICOLMUXA.ISA.ISO_B ICOLMUXA.DLB VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcolmuxa.Isa.MXP9 ICOLMUXA.ISA.NSD ICOLMUXA.ISA.ISO_B ICOLMUXA.NDLB VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcolmuxb.Irw_b.I1.MXNA1 ICOLMUXB.IRW_B.RD_OVRD_N RDA_OVRDB VSSE VPW
+  N11LL_CKT W=0.29U L=0.04U
X_MIcolmuxb.Irw_b.I1.MXPA1 ICOLMUXB.IRW_B.RD_OVRD_N RDA_OVRDB VDDPE VNWP
+  P11LL_CKT W=0.57U L=0.04U
X_MIcolmuxb.Irw_b.I7.MXNA1 ICOLMUXB.IRW_B.PCH_N PCH_BL_B_B VSSE VPW N11LL_CKT
+  W=0.305U L=0.04U
X_MIcolmuxb.Irw_b.I7.MXPA1 ICOLMUXB.IRW_B.PCH_N PCH_BL_B_B VDDPE VNWP
+  P11LL_CKT W=1.18U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I10.MXNA1
+  ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_0.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I10.MXPA1
+  ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_0.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I8.MXNA1 ICOLMUXB.IRW_B.IRW_0.WSEL
+  NWSEL_B[0] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I8.MXNA2 ICOLMUXB.IRW_B.IRW_0.WSEL NWGSEL_B
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I8.MXPA1 ICOLMUXB.IRW_B.IRW_0.WSEL
+  NWSEL_B[0] ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I8.MXPA2
+  ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.I8.P1 NWGSEL_B VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I9.MXNA1 OVRDB_A[0]
+  ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I9.MXNA2 OVRDB_A[0] ICOLMUXB.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I9.MXPA1 OVRDB_A[0]
+  ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwgatedp.I9.MXPA2
+  ICOLMUXB.IRW_B.IRW_0.IRWGATEDP.I9.P1 ICOLMUXB.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXN0 NBLB_B[0] ICOLMUXB.IRW_B.IRW_0.WSEL
+  NDI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXN1 BLB_B[0] ICOLMUXB.IRW_B.IRW_0.WSEL
+  DI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP1 NBLB_B[0] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP10
+  ICOLMUXB.IRW_B.IRW_0.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP3 ICOLMUXB.NDLB NRSEL_B[0] NBLB_B[0]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP4 ICOLMUXB.DLB NRSEL_B[0] BLB_B[0]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP5 NBLB_B[0] BLB_B[0]
+  ICOLMUXB.IRW_B.IRW_0.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP7 BLB_B[0] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP8 NBLB_B[0] ICOLMUXB.IRW_B.PCH_N
+  BLB_B[0] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_0.Irwiso.Icmux.MXP9 BLB_B[0] NBLB_B[0]
+  ICOLMUXB.IRW_B.IRW_0.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I10.MXNA1
+  ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_1.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I10.MXPA1
+  ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_1.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I8.MXNA1 ICOLMUXB.IRW_B.IRW_1.WSEL
+  NWSEL_B[1] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I8.MXNA2 ICOLMUXB.IRW_B.IRW_1.WSEL NWGSEL_B
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I8.MXPA1 ICOLMUXB.IRW_B.IRW_1.WSEL
+  NWSEL_B[1] ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I8.MXPA2
+  ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.I8.P1 NWGSEL_B VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I9.MXNA1 OVRDB_A[1]
+  ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I9.MXNA2 OVRDB_A[1] ICOLMUXB.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I9.MXPA1 OVRDB_A[1]
+  ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwgatedp.I9.MXPA2
+  ICOLMUXB.IRW_B.IRW_1.IRWGATEDP.I9.P1 ICOLMUXB.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXN0 NBLB_B[1] ICOLMUXB.IRW_B.IRW_1.WSEL
+  NDI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXN1 BLB_B[1] ICOLMUXB.IRW_B.IRW_1.WSEL
+  DI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP1 NBLB_B[1] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP10
+  ICOLMUXB.IRW_B.IRW_1.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP3 ICOLMUXB.NDLB NRSEL_B[1] NBLB_B[1]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP4 ICOLMUXB.DLB NRSEL_B[1] BLB_B[1]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP5 NBLB_B[1] BLB_B[1]
+  ICOLMUXB.IRW_B.IRW_1.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP7 BLB_B[1] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP8 NBLB_B[1] ICOLMUXB.IRW_B.PCH_N
+  BLB_B[1] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_1.Irwiso.Icmux.MXP9 BLB_B[1] NBLB_B[1]
+  ICOLMUXB.IRW_B.IRW_1.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I10.MXNA1
+  ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_2.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I10.MXPA1
+  ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_2.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I8.MXNA1 ICOLMUXB.IRW_B.IRW_2.WSEL
+  NWSEL_B[2] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I8.MXNA2 ICOLMUXB.IRW_B.IRW_2.WSEL NWGSEL_B
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I8.MXPA1 ICOLMUXB.IRW_B.IRW_2.WSEL
+  NWSEL_B[2] ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I8.MXPA2
+  ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.I8.P1 NWGSEL_B VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I9.MXNA1 OVRDB_A[2]
+  ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I9.MXNA2 OVRDB_A[2] ICOLMUXB.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I9.MXPA1 OVRDB_A[2]
+  ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwgatedp.I9.MXPA2
+  ICOLMUXB.IRW_B.IRW_2.IRWGATEDP.I9.P1 ICOLMUXB.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXN0 NBLB_B[2] ICOLMUXB.IRW_B.IRW_2.WSEL
+  NDI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXN1 BLB_B[2] ICOLMUXB.IRW_B.IRW_2.WSEL
+  DI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP1 NBLB_B[2] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP10
+  ICOLMUXB.IRW_B.IRW_2.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP3 ICOLMUXB.NDLB NRSEL_B[2] NBLB_B[2]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP4 ICOLMUXB.DLB NRSEL_B[2] BLB_B[2]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP5 NBLB_B[2] BLB_B[2]
+  ICOLMUXB.IRW_B.IRW_2.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP7 BLB_B[2] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP8 NBLB_B[2] ICOLMUXB.IRW_B.PCH_N
+  BLB_B[2] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_2.Irwiso.Icmux.MXP9 BLB_B[2] NBLB_B[2]
+  ICOLMUXB.IRW_B.IRW_2.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I10.MXNA1
+  ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_3.WSEL VSSE VPW
+  N11LL_CKT W=0.19U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I10.MXPA1
+  ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_3.WSEL VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I8.MXNA1 ICOLMUXB.IRW_B.IRW_3.WSEL
+  NWSEL_B[3] VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I8.MXNA2 ICOLMUXB.IRW_B.IRW_3.WSEL NWGSEL_B
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I8.MXPA1 ICOLMUXB.IRW_B.IRW_3.WSEL
+  NWSEL_B[3] ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.I8.P1 VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I8.MXPA2
+  ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.I8.P1 NWGSEL_B VDDPE VNWP P11LL_CKT W=0.68U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I9.MXNA1 OVRDB_A[3]
+  ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.NWSE VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I9.MXNA2 OVRDB_A[3] ICOLMUXB.IRW_B.RD_OVRD_N
+  VSSE VPW N11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I9.MXPA1 OVRDB_A[3]
+  ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.NWSE ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.I9.P1
+  VNWP P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwgatedp.I9.MXPA2
+  ICOLMUXB.IRW_B.IRW_3.IRWGATEDP.I9.P1 ICOLMUXB.IRW_B.RD_OVRD_N VDDPE VNWP
+  P11LL_CKT W=0.68U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXN0 NBLB_B[3] ICOLMUXB.IRW_B.IRW_3.WSEL
+  NDI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXN1 BLB_B[3] ICOLMUXB.IRW_B.IRW_3.WSEL
+  DI_B VPW N11LL_CKT W=1.2U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP1 NBLB_B[3] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP10
+  ICOLMUXB.IRW_B.IRW_3.IRWISO.ICMUX.VVDP NACT_B VDDPE VNWC P11LL_CKT W=0.325U
+  L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP3 ICOLMUXB.NDLB NRSEL_B[3] NBLB_B[3]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP4 ICOLMUXB.DLB NRSEL_B[3] BLB_B[3]
+  VNWC P11LL_CKT W=0.455U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP5 NBLB_B[3] BLB_B[3]
+  ICOLMUXB.IRW_B.IRW_3.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP7 BLB_B[3] ICOLMUXB.IRW_B.PCH_N VDDPE
+  VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP8 NBLB_B[3] ICOLMUXB.IRW_B.PCH_N
+  BLB_B[3] VNWC P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Irw_b.Irw_3.Irwiso.Icmux.MXP9 BLB_B[3] NBLB_B[3]
+  ICOLMUXB.IRW_B.IRW_3.IRWISO.ICMUX.VVDP VNWC P11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Irw_b.MXP13 ICOLMUXB.NDLB ICOLMUXB.IRW_B.PCH_N VDDPE VNWC
+  P11LL_CKT W=0.175U L=0.04U
X_MIcolmuxb.Irw_b.MXP14 ICOLMUXB.DLB ICOLMUXB.IRW_B.PCH_N VDDPE VNWC P11LL_CKT
+  W=0.175U L=0.04U
X_MIcolmuxb.Isa.I12.MXNA1 ICOLMUXB.ISA.SAE ICOLMUXB.ISA.SA_TP_N VSSE VPW
+  N11LL_CKT W=0.25U L=0.04U
X_MIcolmuxb.Isa.I12.MXNA2 ICOLMUXB.ISA.SAE ICOLMUXB.ISA.SA_DLY_TP VSSE VPW
+  N11LL_CKT W=0.25U L=0.04U
X_MIcolmuxb.Isa.I12.MXPA1 ICOLMUXB.ISA.SAE ICOLMUXB.ISA.SA_TP_N
+  ICOLMUXB.ISA.I12.P1 VNWP P11LL_CKT W=0.855U L=0.04U
X_MIcolmuxb.Isa.I12.MXPA2 ICOLMUXB.ISA.I12.P1 ICOLMUXB.ISA.SA_DLY_TP VDDPE
+  VNWP P11LL_CKT W=0.855U L=0.04U
X_MIcolmuxb.Isa.I23.MXNA1 ICOLMUXB.ISA.BSA_DLY_TP_N ICOLMUXB.ISA.SA_DLY_TP
+  VSSE VPW N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxb.Isa.I23.MXPA1 ICOLMUXB.ISA.BSA_DLY_TP_N ICOLMUXB.ISA.SA_DLY_TP
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxb.Isa.I24.MXNA1 ICOLMUXB.ISA.SA_PRE ICOLMUXB.ISA.SA_TP_N VSSE VPW
+  N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxb.Isa.I24.MXNA2 ICOLMUXB.ISA.SA_PRE ICOLMUXB.ISA.BSA_DLY_TP_N VSSE
+  VPW N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxb.Isa.I24.MXPA1 ICOLMUXB.ISA.SA_PRE ICOLMUXB.ISA.SA_TP_N
+  ICOLMUXB.ISA.I24.P1 VNWP P11LL_CKT W=0.2U L=0.04U
X_MIcolmuxb.Isa.I24.MXPA2 ICOLMUXB.ISA.I24.P1 ICOLMUXB.ISA.BSA_DLY_TP_N VDDPE
+  VNWP P11LL_CKT W=0.2U L=0.04U
X_MIcolmuxb.Isa.I25.MXNA1 ICOLMUXB.ISA.SA_PRE_N ICOLMUXB.ISA.SA_PRE VSSE VPW
+  N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxb.Isa.I25.MXPA1 ICOLMUXB.ISA.SA_PRE_N ICOLMUXB.ISA.SA_PRE VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcolmuxb.Isa.I27.MXNA1 ICOLMUXB.ISA.SA_TP_N SA_TP_B VSSE VPW N11LL_CKT
+  W=0.28U L=0.04U
X_MIcolmuxb.Isa.I27.MXPA1 ICOLMUXB.ISA.SA_TP_N SA_TP_B VDDPE VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_MIcolmuxb.Isa.I28.MXNA1 ICOLMUXB.ISA.SA_DLY_TP NDSA_TP_B VSSE VPW N11LL_CKT
+  W=0.23U L=0.04U
X_MIcolmuxb.Isa.I28.MXPA1 ICOLMUXB.ISA.SA_DLY_TP NDSA_TP_B VDDPE VNWP
+  P11LL_CKT W=0.45U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I62.MXNA1 GDL_B ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT
+  VSSE VPW N11LL_CKT W=1.86U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I62.MXPA1 GDL_B ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT
+  VDDPE VNWP P11LL_CKT W=2.18U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I68.MXNA1 ICOLMUXB.ISA.ISALAT.ISLAT.WCLK_WT
+  NWCLK_WT_B VSSE VPW N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I68.MXPA1 ICOLMUXB.ISA.ISALAT.ISLAT.WCLK_WT
+  NWCLK_WT_B VDDPE VNWP P11LL_CKT W=0.3U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I69.MXNA1 ICOLMUXB.ISA.ISALAT.ISLAT.I69.N1 NDI_B
+  VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I69.MXNOE ICOLMUXB.ISA.ISALAT.ISLAT.NSD_LAT
+  ICOLMUXB.ISA.ISALAT.ISLAT.WCLK_WT ICOLMUXB.ISA.ISALAT.ISLAT.I69.N1 VPW
+  N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I69.MXPA1 ICOLMUXB.ISA.ISALAT.ISLAT.I69.P1 NDI_B
+  VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I69.MXPOEN ICOLMUXB.ISA.ISALAT.ISLAT.NSD_LAT
+  NWCLK_WT_B ICOLMUXB.ISA.ISALAT.ISLAT.I69.P1 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I70.MXNA1 ICOLMUXB.ISA.ISALAT.ISLAT.I70.N1
+  ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT VSSE VPW N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I70.MXNOE ICOLMUXB.ISA.ISALAT.ISLAT.NSD_LAT
+  NWCLK_WT_B ICOLMUXB.ISA.ISALAT.ISLAT.I70.N1 VPW N11LL_CKT W=0.35U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I70.MXPA1 ICOLMUXB.ISA.ISALAT.ISLAT.I70.P1
+  ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I70.MXPOEN ICOLMUXB.ISA.ISALAT.ISLAT.NSD_LAT
+  ICOLMUXB.ISA.ISALAT.ISLAT.WCLK_WT ICOLMUXB.ISA.ISALAT.ISLAT.I70.P1 VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I82.MXNA1 ICOLMUXB.ISA.ISALAT.ISLAT.NLAT_E
+  ICOLMUXB.ISA.SAE VSSE VPW N11LL_CKT W=0.135U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.I82.MXPA1 ICOLMUXB.ISA.ISALAT.ISLAT.NLAT_E
+  ICOLMUXB.ISA.SAE VDDPE VNWP P11LL_CKT W=0.27U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MXN8 ICOLMUXB.ISA.ISALAT.ISLAT.N1B
+  ICOLMUXB.ISA.ISALAT.ISLAT.NSD_LAT VSSE VPW N11LL_CKT W=0.5U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MXN9 ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXB.ISA.ISALAT.ISLAT.NLAT_E ICOLMUXB.ISA.ISALAT.ISLAT.N1B VPW
+  N11LL_CKT W=0.5U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MXP6 ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXB.ISA.SAE ICOLMUXB.ISA.ISALAT.ISLAT.P1B VNWP P11LL_CKT W=0.8U
+  L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MXP7 ICOLMUXB.ISA.ISALAT.ISLAT.P1B
+  ICOLMUXB.ISA.ISALAT.ISLAT.NSD_LAT VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MXPs ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXB.ISA.SD ICOLMUXB.ISA.ISALAT.ISLAT.P1A VNWP P11LL_CKT W=1.03U
+  L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MX_ndmy ICOLMUXB.ISA.ISALAT.ISLAT.NSD_DUM
+  ICOLMUXB.ISA.NSD ICOLMUXB.ISA.ISALAT.ISLAT.N1A VPW N11LL_CKT W=0.57U
+  L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MX_nlat ICOLMUXB.ISA.ISALAT.ISLAT.N1A
+  ICOLMUXB.ISA.SAE VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MX_pdmy ICOLMUXB.ISA.ISALAT.ISLAT.NSD_DUM
+  ICOLMUXB.ISA.NSD ICOLMUXB.ISA.ISALAT.ISLAT.P1A VNWP P11LL_CKT W=1.03U
+  L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MX_pnsae ICOLMUXB.ISA.ISALAT.ISLAT.P1A
+  ICOLMUXB.ISA.ISALAT.ISLAT.NLAT_E VDDPE VNWP P11LL_CKT W=1.03U L=0.04U
X_MIcolmuxb.Isa.Isalat.Islat.MX_sd_n ICOLMUXB.ISA.ISALAT.ISLAT.SD_LAT
+  ICOLMUXB.ISA.SD ICOLMUXB.ISA.ISALAT.ISLAT.N1A VPW N11LL_CKT W=0.57U L=0.04U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXN17 ICOLMUXB.ISA.NSD ICOLMUXB.ISA.SD
+  ICOLMUXB.ISA.ISAMP.NET18 VPW N11LL_CKT W=2.4U L=0.08U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXN18 ICOLMUXB.ISA.ISAMP.NET18
+  ICOLMUXB.ISA.SAE VSSE VPW N11LL_CKT W=1.11U L=0.04U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXN19 ICOLMUXB.ISA.SD ICOLMUXB.ISA.NSD
+  ICOLMUXB.ISA.ISAMP.NET18 VPW N11LL_CKT W=2.4U L=0.08U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXP24 ICOLMUXB.ISA.NSD ICOLMUXB.ISA.SA_PRE_N
+  VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXP25 ICOLMUXB.ISA.NSD ICOLMUXB.ISA.SA_PRE_N
+  ICOLMUXB.ISA.SD VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXP26 ICOLMUXB.ISA.SD ICOLMUXB.ISA.SA_PRE_N
+  VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXP27 ICOLMUXB.ISA.NSD ICOLMUXB.ISA.SD VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxb.Isa.Isamp.Isenseamp.MXP28 ICOLMUXB.ISA.SD ICOLMUXB.ISA.NSD VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcolmuxb.Isa.MXN13 NDI_B DATAIN_B VSSE VPW N11LL_CKT W=2.46U L=0.04U
X_MIcolmuxb.Isa.MXN14 DI_B NDI_B VSSE VPW N11LL_CKT W=2.46U L=0.04U
X_MIcolmuxb.Isa.MXN16 ICOLMUXB.ISA.ISO_B ICOLMUXB.ISA.SA_TP_N VSSE VPW
+  N11LL_CKT W=0.12U L=0.04U
X_MIcolmuxb.Isa.MXP17 NDI_B DATAIN_B RET_SHR VNWP P11LL_CKT W=2.32U L=0.04U
X_MIcolmuxb.Isa.MXP18 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MIcolmuxb.Isa.MXP19 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.565U L=0.04U
X_MIcolmuxb.Isa.MXP20 DI_B NDI_B RET_SHR VNWP P11LL_CKT W=2.32U L=0.04U
X_MIcolmuxb.Isa.MXP21 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.505U L=0.04U
X_MIcolmuxb.Isa.MXP22 RET_SHR NACT_T VDDPE VNWP P11LL_CKT W=0.505U L=0.04U
X_MIcolmuxb.Isa.MXP25 ICOLMUXB.ISA.ISO_B ICOLMUXB.ISA.SA_TP_N
+  ICOLMUXB.ISA.NET109 VNWP P11LL_CKT W=0.26U L=0.04U
X_MIcolmuxb.Isa.MXP26 ICOLMUXB.ISA.NET109 ICOLMUXB.ISA.SA_TP_N VDDPE VNWP
+  P11LL_CKT W=0.26U L=0.04U
X_MIcolmuxb.Isa.MXP8 ICOLMUXB.ISA.SD ICOLMUXB.ISA.ISO_B ICOLMUXB.DLB VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcolmuxb.Isa.MXP9 ICOLMUXB.ISA.NSD ICOLMUXB.ISA.ISO_B ICOLMUXB.NDLB VNWP
+  P11LL_CKT W=0.71U L=0.04U
.ENDS SRAMdpw64d256CMUXSA
****
.SUBCKT SRAMdpw64d256COLMX0DN32O BLB_A[0]_0 BLB_A[0]_1 BLB_A[0]_2 BLB_A[0]_3
+  BLB_A[0]_4 BLB_A[0]_5 BLB_A[0]_6 BLB_A[0]_7 BLB_A[0]_8 BLB_A[0]_9
+  BLB_A[0]_10 BLB_A[0]_11 BLB_A[0]_12 BLB_A[0]_13 BLB_A[0]_14 BLB_A[0]_15
+  BLB_A[0]_16 BLB_A[0]_17 BLB_A[0]_18 BLB_A[0]_19 BLB_A[0]_20 BLB_A[0]_21
+  BLB_A[0]_22 BLB_A[0]_23 BLB_A[0]_24 BLB_A[0]_25 BLB_A[0]_26 BLB_A[0]_27
+  BLB_A[0]_28 BLB_A[0]_29 BLB_A[0]_30 BLB_A[0]_31 BLB_A[1]_0 BLB_A[1]_1
+  BLB_A[1]_2 BLB_A[1]_3 BLB_A[1]_4 BLB_A[1]_5 BLB_A[1]_6 BLB_A[1]_7
+  BLB_A[1]_8 BLB_A[1]_9 BLB_A[1]_10 BLB_A[1]_11 BLB_A[1]_12 BLB_A[1]_13
+  BLB_A[1]_14 BLB_A[1]_15 BLB_A[1]_16 BLB_A[1]_17 BLB_A[1]_18 BLB_A[1]_19
+  BLB_A[1]_20 BLB_A[1]_21 BLB_A[1]_22 BLB_A[1]_23 BLB_A[1]_24 BLB_A[1]_25
+  BLB_A[1]_26 BLB_A[1]_27 BLB_A[1]_28 BLB_A[1]_29 BLB_A[1]_30 BLB_A[1]_31
+  BLB_A[2]_0 BLB_A[2]_1 BLB_A[2]_2 BLB_A[2]_3 BLB_A[2]_4 BLB_A[2]_5
+  BLB_A[2]_6 BLB_A[2]_7 BLB_A[2]_8 BLB_A[2]_9 BLB_A[2]_10 BLB_A[2]_11
+  BLB_A[2]_12 BLB_A[2]_13 BLB_A[2]_14 BLB_A[2]_15 BLB_A[2]_16 BLB_A[2]_17
+  BLB_A[2]_18 BLB_A[2]_19 BLB_A[2]_20 BLB_A[2]_21 BLB_A[2]_22 BLB_A[2]_23
+  BLB_A[2]_24 BLB_A[2]_25 BLB_A[2]_26 BLB_A[2]_27 BLB_A[2]_28 BLB_A[2]_29
+  BLB_A[2]_30 BLB_A[2]_31 BLB_A[3]_0 BLB_A[3]_1 BLB_A[3]_2 BLB_A[3]_3
+  BLB_A[3]_4 BLB_A[3]_5 BLB_A[3]_6 BLB_A[3]_7 BLB_A[3]_8 BLB_A[3]_9
+  BLB_A[3]_10 BLB_A[3]_11 BLB_A[3]_12 BLB_A[3]_13 BLB_A[3]_14 BLB_A[3]_15
+  BLB_A[3]_16 BLB_A[3]_17 BLB_A[3]_18 BLB_A[3]_19 BLB_A[3]_20 BLB_A[3]_21
+  BLB_A[3]_22 BLB_A[3]_23 BLB_A[3]_24 BLB_A[3]_25 BLB_A[3]_26 BLB_A[3]_27
+  BLB_A[3]_28 BLB_A[3]_29 BLB_A[3]_30 BLB_A[3]_31 BLB_B[0]_0 BLB_B[0]_1
+  BLB_B[0]_2 BLB_B[0]_3 BLB_B[0]_4 BLB_B[0]_5 BLB_B[0]_6 BLB_B[0]_7
+  BLB_B[0]_8 BLB_B[0]_9 BLB_B[0]_10 BLB_B[0]_11 BLB_B[0]_12 BLB_B[0]_13
+  BLB_B[0]_14 BLB_B[0]_15 BLB_B[0]_16 BLB_B[0]_17 BLB_B[0]_18 BLB_B[0]_19
+  BLB_B[0]_20 BLB_B[0]_21 BLB_B[0]_22 BLB_B[0]_23 BLB_B[0]_24 BLB_B[0]_25
+  BLB_B[0]_26 BLB_B[0]_27 BLB_B[0]_28 BLB_B[0]_29 BLB_B[0]_30 BLB_B[0]_31
+  BLB_B[1]_0 BLB_B[1]_1 BLB_B[1]_2 BLB_B[1]_3 BLB_B[1]_4 BLB_B[1]_5
+  BLB_B[1]_6 BLB_B[1]_7 BLB_B[1]_8 BLB_B[1]_9 BLB_B[1]_10 BLB_B[1]_11
+  BLB_B[1]_12 BLB_B[1]_13 BLB_B[1]_14 BLB_B[1]_15 BLB_B[1]_16 BLB_B[1]_17
+  BLB_B[1]_18 BLB_B[1]_19 BLB_B[1]_20 BLB_B[1]_21 BLB_B[1]_22 BLB_B[1]_23
+  BLB_B[1]_24 BLB_B[1]_25 BLB_B[1]_26 BLB_B[1]_27 BLB_B[1]_28 BLB_B[1]_29
+  BLB_B[1]_30 BLB_B[1]_31 BLB_B[2]_0 BLB_B[2]_1 BLB_B[2]_2 BLB_B[2]_3
+  BLB_B[2]_4 BLB_B[2]_5 BLB_B[2]_6 BLB_B[2]_7 BLB_B[2]_8 BLB_B[2]_9
+  BLB_B[2]_10 BLB_B[2]_11 BLB_B[2]_12 BLB_B[2]_13 BLB_B[2]_14 BLB_B[2]_15
+  BLB_B[2]_16 BLB_B[2]_17 BLB_B[2]_18 BLB_B[2]_19 BLB_B[2]_20 BLB_B[2]_21
+  BLB_B[2]_22 BLB_B[2]_23 BLB_B[2]_24 BLB_B[2]_25 BLB_B[2]_26 BLB_B[2]_27
+  BLB_B[2]_28 BLB_B[2]_29 BLB_B[2]_30 BLB_B[2]_31 BLB_B[3]_0 BLB_B[3]_1
+  BLB_B[3]_2 BLB_B[3]_3 BLB_B[3]_4 BLB_B[3]_5 BLB_B[3]_6 BLB_B[3]_7
+  BLB_B[3]_8 BLB_B[3]_9 BLB_B[3]_10 BLB_B[3]_11 BLB_B[3]_12 BLB_B[3]_13
+  BLB_B[3]_14 BLB_B[3]_15 BLB_B[3]_16 BLB_B[3]_17 BLB_B[3]_18 BLB_B[3]_19
+  BLB_B[3]_20 BLB_B[3]_21 BLB_B[3]_22 BLB_B[3]_23 BLB_B[3]_24 BLB_B[3]_25
+  BLB_B[3]_26 BLB_B[3]_27 BLB_B[3]_28 BLB_B[3]_29 BLB_B[3]_30 BLB_B[3]_31
+  DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5
+  DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11
+  DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17
+  DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23
+  DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29
+  DATAIN_A_30 DATAIN_A_31 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3
+  DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9
+  DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15
+  DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21
+  DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27
+  DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 GDL_A_0 GDL_A_1 GDL_A_2
+  GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11
+  GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19
+  GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27
+  GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4
+  GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13
+  GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21
+  GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29
+  GDL_B_30 GDL_B_31 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_0
+  NBLB_A[0]_1 NBLB_A[0]_2 NBLB_A[0]_3 NBLB_A[0]_4 NBLB_A[0]_5 NBLB_A[0]_6
+  NBLB_A[0]_7 NBLB_A[0]_8 NBLB_A[0]_9 NBLB_A[0]_10 NBLB_A[0]_11 NBLB_A[0]_12
+  NBLB_A[0]_13 NBLB_A[0]_14 NBLB_A[0]_15 NBLB_A[0]_16 NBLB_A[0]_17
+  NBLB_A[0]_18 NBLB_A[0]_19 NBLB_A[0]_20 NBLB_A[0]_21 NBLB_A[0]_22
+  NBLB_A[0]_23 NBLB_A[0]_24 NBLB_A[0]_25 NBLB_A[0]_26 NBLB_A[0]_27
+  NBLB_A[0]_28 NBLB_A[0]_29 NBLB_A[0]_30 NBLB_A[0]_31 NBLB_A[1]_0 NBLB_A[1]_1
+  NBLB_A[1]_2 NBLB_A[1]_3 NBLB_A[1]_4 NBLB_A[1]_5 NBLB_A[1]_6 NBLB_A[1]_7
+  NBLB_A[1]_8 NBLB_A[1]_9 NBLB_A[1]_10 NBLB_A[1]_11 NBLB_A[1]_12 NBLB_A[1]_13
+  NBLB_A[1]_14 NBLB_A[1]_15 NBLB_A[1]_16 NBLB_A[1]_17 NBLB_A[1]_18
+  NBLB_A[1]_19 NBLB_A[1]_20 NBLB_A[1]_21 NBLB_A[1]_22 NBLB_A[1]_23
+  NBLB_A[1]_24 NBLB_A[1]_25 NBLB_A[1]_26 NBLB_A[1]_27 NBLB_A[1]_28
+  NBLB_A[1]_29 NBLB_A[1]_30 NBLB_A[1]_31 NBLB_A[2]_0 NBLB_A[2]_1 NBLB_A[2]_2
+  NBLB_A[2]_3 NBLB_A[2]_4 NBLB_A[2]_5 NBLB_A[2]_6 NBLB_A[2]_7 NBLB_A[2]_8
+  NBLB_A[2]_9 NBLB_A[2]_10 NBLB_A[2]_11 NBLB_A[2]_12 NBLB_A[2]_13
+  NBLB_A[2]_14 NBLB_A[2]_15 NBLB_A[2]_16 NBLB_A[2]_17 NBLB_A[2]_18
+  NBLB_A[2]_19 NBLB_A[2]_20 NBLB_A[2]_21 NBLB_A[2]_22 NBLB_A[2]_23
+  NBLB_A[2]_24 NBLB_A[2]_25 NBLB_A[2]_26 NBLB_A[2]_27 NBLB_A[2]_28
+  NBLB_A[2]_29 NBLB_A[2]_30 NBLB_A[2]_31 NBLB_A[3]_0 NBLB_A[3]_1 NBLB_A[3]_2
+  NBLB_A[3]_3 NBLB_A[3]_4 NBLB_A[3]_5 NBLB_A[3]_6 NBLB_A[3]_7 NBLB_A[3]_8
+  NBLB_A[3]_9 NBLB_A[3]_10 NBLB_A[3]_11 NBLB_A[3]_12 NBLB_A[3]_13
+  NBLB_A[3]_14 NBLB_A[3]_15 NBLB_A[3]_16 NBLB_A[3]_17 NBLB_A[3]_18
+  NBLB_A[3]_19 NBLB_A[3]_20 NBLB_A[3]_21 NBLB_A[3]_22 NBLB_A[3]_23
+  NBLB_A[3]_24 NBLB_A[3]_25 NBLB_A[3]_26 NBLB_A[3]_27 NBLB_A[3]_28
+  NBLB_A[3]_29 NBLB_A[3]_30 NBLB_A[3]_31 NBLB_B[0]_0 NBLB_B[0]_1 NBLB_B[0]_2
+  NBLB_B[0]_3 NBLB_B[0]_4 NBLB_B[0]_5 NBLB_B[0]_6 NBLB_B[0]_7 NBLB_B[0]_8
+  NBLB_B[0]_9 NBLB_B[0]_10 NBLB_B[0]_11 NBLB_B[0]_12 NBLB_B[0]_13
+  NBLB_B[0]_14 NBLB_B[0]_15 NBLB_B[0]_16 NBLB_B[0]_17 NBLB_B[0]_18
+  NBLB_B[0]_19 NBLB_B[0]_20 NBLB_B[0]_21 NBLB_B[0]_22 NBLB_B[0]_23
+  NBLB_B[0]_24 NBLB_B[0]_25 NBLB_B[0]_26 NBLB_B[0]_27 NBLB_B[0]_28
+  NBLB_B[0]_29 NBLB_B[0]_30 NBLB_B[0]_31 NBLB_B[1]_0 NBLB_B[1]_1 NBLB_B[1]_2
+  NBLB_B[1]_3 NBLB_B[1]_4 NBLB_B[1]_5 NBLB_B[1]_6 NBLB_B[1]_7 NBLB_B[1]_8
+  NBLB_B[1]_9 NBLB_B[1]_10 NBLB_B[1]_11 NBLB_B[1]_12 NBLB_B[1]_13
+  NBLB_B[1]_14 NBLB_B[1]_15 NBLB_B[1]_16 NBLB_B[1]_17 NBLB_B[1]_18
+  NBLB_B[1]_19 NBLB_B[1]_20 NBLB_B[1]_21 NBLB_B[1]_22 NBLB_B[1]_23
+  NBLB_B[1]_24 NBLB_B[1]_25 NBLB_B[1]_26 NBLB_B[1]_27 NBLB_B[1]_28
+  NBLB_B[1]_29 NBLB_B[1]_30 NBLB_B[1]_31 NBLB_B[2]_0 NBLB_B[2]_1 NBLB_B[2]_2
+  NBLB_B[2]_3 NBLB_B[2]_4 NBLB_B[2]_5 NBLB_B[2]_6 NBLB_B[2]_7 NBLB_B[2]_8
+  NBLB_B[2]_9 NBLB_B[2]_10 NBLB_B[2]_11 NBLB_B[2]_12 NBLB_B[2]_13
+  NBLB_B[2]_14 NBLB_B[2]_15 NBLB_B[2]_16 NBLB_B[2]_17 NBLB_B[2]_18
+  NBLB_B[2]_19 NBLB_B[2]_20 NBLB_B[2]_21 NBLB_B[2]_22 NBLB_B[2]_23
+  NBLB_B[2]_24 NBLB_B[2]_25 NBLB_B[2]_26 NBLB_B[2]_27 NBLB_B[2]_28
+  NBLB_B[2]_29 NBLB_B[2]_30 NBLB_B[2]_31 NBLB_B[3]_0 NBLB_B[3]_1 NBLB_B[3]_2
+  NBLB_B[3]_3 NBLB_B[3]_4 NBLB_B[3]_5 NBLB_B[3]_6 NBLB_B[3]_7 NBLB_B[3]_8
+  NBLB_B[3]_9 NBLB_B[3]_10 NBLB_B[3]_11 NBLB_B[3]_12 NBLB_B[3]_13
+  NBLB_B[3]_14 NBLB_B[3]_15 NBLB_B[3]_16 NBLB_B[3]_17 NBLB_B[3]_18
+  NBLB_B[3]_19 NBLB_B[3]_20 NBLB_B[3]_21 NBLB_B[3]_22 NBLB_B[3]_23
+  NBLB_B[3]_24 NBLB_B[3]_25 NBLB_B[3]_26 NBLB_B[3]_27 NBLB_B[3]_28
+  NBLB_B[3]_29 NBLB_B[3]_30 NBLB_B[3]_31 NDSA_TP_A NDSA_TP_B NRSEL_A[0]
+  NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2]
+  NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2
+  NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8
+  NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14
+  NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20
+  NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26
+  NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_B_0
+  NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6
+  NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12
+  NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18
+  NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24
+  NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30
+  NWGSEL_B_31 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0]
+  NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB
+  SA_TIELO SA_TP_A SA_TP_B VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5
+  VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13
+  VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21
+  VDDCE_22 VDDCE_23 VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29
+  VDDCE_30 VDDCE_31 VDDPE VNWC VPW
** SRAMdpw64d256COLMX0DN32O: 9920 flat devices **
XCMUXSALSB0 BLB_A[0]_31 BLB_A[1]_31 BLB_A[2]_31 BLB_A[3]_31 BLB_B[0]_31
+  BLB_B[1]_31 BLB_B[2]_31 BLB_B[3]_31 DATAIN_A_31 DATAIN_B_31 GDL_A_31
+  GDL_B_31 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_31 NBLB_A[1]_31
+  NBLB_A[2]_31 NBLB_A[3]_31 NBLB_B[0]_31 NBLB_B[1]_31 NBLB_B[2]_31
+  NBLB_B[3]_31 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_31 NWGSEL_B_31 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_31 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSALSB1 BLB_A[0]_30 BLB_A[1]_30 BLB_A[2]_30 BLB_A[3]_30 BLB_B[0]_30
+  BLB_B[1]_30 BLB_B[2]_30 BLB_B[3]_30 DATAIN_A_30 DATAIN_B_30 GDL_A_30
+  GDL_B_30 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_30 NBLB_A[1]_30
+  NBLB_A[2]_30 NBLB_A[3]_30 NBLB_B[0]_30 NBLB_B[1]_30 NBLB_B[2]_30
+  NBLB_B[3]_30 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_30 NWGSEL_B_30 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_30 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSALSB2 BLB_A[0]_29 BLB_A[1]_29 BLB_A[2]_29 BLB_A[3]_29 BLB_B[0]_29
+  BLB_B[1]_29 BLB_B[2]_29 BLB_B[3]_29 DATAIN_A_29 DATAIN_B_29 GDL_A_29
+  GDL_B_29 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_29 NBLB_A[1]_29
+  NBLB_A[2]_29 NBLB_A[3]_29 NBLB_B[0]_29 NBLB_B[1]_29 NBLB_B[2]_29
+  NBLB_B[3]_29 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_29 NWGSEL_B_29 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_29 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSALSB3 BLB_A[0]_28 BLB_A[1]_28 BLB_A[2]_28 BLB_A[3]_28 BLB_B[0]_28
+  BLB_B[1]_28 BLB_B[2]_28 BLB_B[3]_28 DATAIN_A_28 DATAIN_B_28 GDL_A_28
+  GDL_B_28 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_28 NBLB_A[1]_28
+  NBLB_A[2]_28 NBLB_A[3]_28 NBLB_B[0]_28 NBLB_B[1]_28 NBLB_B[2]_28
+  NBLB_B[3]_28 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_28 NWGSEL_B_28 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_28 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSAMSB0 BLB_A[0]_3 BLB_A[1]_3 BLB_A[2]_3 BLB_A[3]_3 BLB_B[0]_3 BLB_B[1]_3
+  BLB_B[2]_3 BLB_B[3]_3 DATAIN_A_3 DATAIN_B_3 GDL_A_3 GDL_B_3 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_3 NBLB_A[1]_3 NBLB_A[2]_3
+  NBLB_A[3]_3 NBLB_B[0]_3 NBLB_B[1]_3 NBLB_B[2]_3 NBLB_B[3]_3 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_3 NWGSEL_B_3
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_3 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSAMSB1 BLB_A[0]_2 BLB_A[1]_2 BLB_A[2]_2 BLB_A[3]_2 BLB_B[0]_2 BLB_B[1]_2
+  BLB_B[2]_2 BLB_B[3]_2 DATAIN_A_2 DATAIN_B_2 GDL_A_2 GDL_B_2 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_2 NBLB_A[1]_2 NBLB_A[2]_2
+  NBLB_A[3]_2 NBLB_B[0]_2 NBLB_B[1]_2 NBLB_B[2]_2 NBLB_B[3]_2 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_2 NWGSEL_B_2
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_2 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSAMSB2 BLB_A[0]_1 BLB_A[1]_1 BLB_A[2]_1 BLB_A[3]_1 BLB_B[0]_1 BLB_B[1]_1
+  BLB_B[2]_1 BLB_B[3]_1 DATAIN_A_1 DATAIN_B_1 GDL_A_1 GDL_B_1 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_1 NBLB_A[1]_1 NBLB_A[2]_1
+  NBLB_A[3]_1 NBLB_B[0]_1 NBLB_B[1]_1 NBLB_B[2]_1 NBLB_B[3]_1 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_1 NWGSEL_B_1
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_1 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSAMSB3 BLB_A[0]_0 BLB_A[1]_0 BLB_A[2]_0 BLB_A[3]_0 BLB_B[0]_0 BLB_B[1]_0
+  BLB_B[2]_0 BLB_B[3]_0 DATAIN_A_0 DATAIN_B_0 GDL_A_0 GDL_B_0 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_0 NBLB_A[1]_0 NBLB_A[2]_0
+  NBLB_A[3]_0 NBLB_B[0]_0 NBLB_B[1]_0 NBLB_B[2]_0 NBLB_B[3]_0 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_0 NWGSEL_B_0
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_0 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[10] BLB_A[0]_21 BLB_A[1]_21 BLB_A[2]_21 BLB_A[3]_21 BLB_B[0]_21
+  BLB_B[1]_21 BLB_B[2]_21 BLB_B[3]_21 DATAIN_A_21 DATAIN_B_21 GDL_A_21
+  GDL_B_21 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_21 NBLB_A[1]_21
+  NBLB_A[2]_21 NBLB_A[3]_21 NBLB_B[0]_21 NBLB_B[1]_21 NBLB_B[2]_21
+  NBLB_B[3]_21 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_21 NWGSEL_B_21 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_21 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[11] BLB_A[0]_20 BLB_A[1]_20 BLB_A[2]_20 BLB_A[3]_20 BLB_B[0]_20
+  BLB_B[1]_20 BLB_B[2]_20 BLB_B[3]_20 DATAIN_A_20 DATAIN_B_20 GDL_A_20
+  GDL_B_20 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_20 NBLB_A[1]_20
+  NBLB_A[2]_20 NBLB_A[3]_20 NBLB_B[0]_20 NBLB_B[1]_20 NBLB_B[2]_20
+  NBLB_B[3]_20 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_20 NWGSEL_B_20 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_20 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[12] BLB_A[0]_19 BLB_A[1]_19 BLB_A[2]_19 BLB_A[3]_19 BLB_B[0]_19
+  BLB_B[1]_19 BLB_B[2]_19 BLB_B[3]_19 DATAIN_A_19 DATAIN_B_19 GDL_A_19
+  GDL_B_19 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_19 NBLB_A[1]_19
+  NBLB_A[2]_19 NBLB_A[3]_19 NBLB_B[0]_19 NBLB_B[1]_19 NBLB_B[2]_19
+  NBLB_B[3]_19 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_19 NWGSEL_B_19 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_19 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[13] BLB_A[0]_18 BLB_A[1]_18 BLB_A[2]_18 BLB_A[3]_18 BLB_B[0]_18
+  BLB_B[1]_18 BLB_B[2]_18 BLB_B[3]_18 DATAIN_A_18 DATAIN_B_18 GDL_A_18
+  GDL_B_18 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_18 NBLB_A[1]_18
+  NBLB_A[2]_18 NBLB_A[3]_18 NBLB_B[0]_18 NBLB_B[1]_18 NBLB_B[2]_18
+  NBLB_B[3]_18 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_18 NWGSEL_B_18 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_18 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[14] BLB_A[0]_17 BLB_A[1]_17 BLB_A[2]_17 BLB_A[3]_17 BLB_B[0]_17
+  BLB_B[1]_17 BLB_B[2]_17 BLB_B[3]_17 DATAIN_A_17 DATAIN_B_17 GDL_A_17
+  GDL_B_17 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_17 NBLB_A[1]_17
+  NBLB_A[2]_17 NBLB_A[3]_17 NBLB_B[0]_17 NBLB_B[1]_17 NBLB_B[2]_17
+  NBLB_B[3]_17 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_17 NWGSEL_B_17 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_17 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[15] BLB_A[0]_16 BLB_A[1]_16 BLB_A[2]_16 BLB_A[3]_16 BLB_B[0]_16
+  BLB_B[1]_16 BLB_B[2]_16 BLB_B[3]_16 DATAIN_A_16 DATAIN_B_16 GDL_A_16
+  GDL_B_16 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_16 NBLB_A[1]_16
+  NBLB_A[2]_16 NBLB_A[3]_16 NBLB_B[0]_16 NBLB_B[1]_16 NBLB_B[2]_16
+  NBLB_B[3]_16 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_16 NWGSEL_B_16 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_16 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[16] BLB_A[0]_15 BLB_A[1]_15 BLB_A[2]_15 BLB_A[3]_15 BLB_B[0]_15
+  BLB_B[1]_15 BLB_B[2]_15 BLB_B[3]_15 DATAIN_A_15 DATAIN_B_15 GDL_A_15
+  GDL_B_15 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_15 NBLB_A[1]_15
+  NBLB_A[2]_15 NBLB_A[3]_15 NBLB_B[0]_15 NBLB_B[1]_15 NBLB_B[2]_15
+  NBLB_B[3]_15 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_15 NWGSEL_B_15 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_15 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[17] BLB_A[0]_14 BLB_A[1]_14 BLB_A[2]_14 BLB_A[3]_14 BLB_B[0]_14
+  BLB_B[1]_14 BLB_B[2]_14 BLB_B[3]_14 DATAIN_A_14 DATAIN_B_14 GDL_A_14
+  GDL_B_14 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_14 NBLB_A[1]_14
+  NBLB_A[2]_14 NBLB_A[3]_14 NBLB_B[0]_14 NBLB_B[1]_14 NBLB_B[2]_14
+  NBLB_B[3]_14 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_14 NWGSEL_B_14 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_14 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[18] BLB_A[0]_13 BLB_A[1]_13 BLB_A[2]_13 BLB_A[3]_13 BLB_B[0]_13
+  BLB_B[1]_13 BLB_B[2]_13 BLB_B[3]_13 DATAIN_A_13 DATAIN_B_13 GDL_A_13
+  GDL_B_13 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_13 NBLB_A[1]_13
+  NBLB_A[2]_13 NBLB_A[3]_13 NBLB_B[0]_13 NBLB_B[1]_13 NBLB_B[2]_13
+  NBLB_B[3]_13 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_13 NWGSEL_B_13 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_13 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[19] BLB_A[0]_12 BLB_A[1]_12 BLB_A[2]_12 BLB_A[3]_12 BLB_B[0]_12
+  BLB_B[1]_12 BLB_B[2]_12 BLB_B[3]_12 DATAIN_A_12 DATAIN_B_12 GDL_A_12
+  GDL_B_12 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_12 NBLB_A[1]_12
+  NBLB_A[2]_12 NBLB_A[3]_12 NBLB_B[0]_12 NBLB_B[1]_12 NBLB_B[2]_12
+  NBLB_B[3]_12 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_12 NWGSEL_B_12 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_12 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[20] BLB_A[0]_11 BLB_A[1]_11 BLB_A[2]_11 BLB_A[3]_11 BLB_B[0]_11
+  BLB_B[1]_11 BLB_B[2]_11 BLB_B[3]_11 DATAIN_A_11 DATAIN_B_11 GDL_A_11
+  GDL_B_11 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_11 NBLB_A[1]_11
+  NBLB_A[2]_11 NBLB_A[3]_11 NBLB_B[0]_11 NBLB_B[1]_11 NBLB_B[2]_11
+  NBLB_B[3]_11 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_11 NWGSEL_B_11 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_11 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[21] BLB_A[0]_10 BLB_A[1]_10 BLB_A[2]_10 BLB_A[3]_10 BLB_B[0]_10
+  BLB_B[1]_10 BLB_B[2]_10 BLB_B[3]_10 DATAIN_A_10 DATAIN_B_10 GDL_A_10
+  GDL_B_10 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_10 NBLB_A[1]_10
+  NBLB_A[2]_10 NBLB_A[3]_10 NBLB_B[0]_10 NBLB_B[1]_10 NBLB_B[2]_10
+  NBLB_B[3]_10 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_10 NWGSEL_B_10 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_10 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[22] BLB_A[0]_9 BLB_A[1]_9 BLB_A[2]_9 BLB_A[3]_9 BLB_B[0]_9 BLB_B[1]_9
+  BLB_B[2]_9 BLB_B[3]_9 DATAIN_A_9 DATAIN_B_9 GDL_A_9 GDL_B_9 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_9 NBLB_A[1]_9 NBLB_A[2]_9
+  NBLB_A[3]_9 NBLB_B[0]_9 NBLB_B[1]_9 NBLB_B[2]_9 NBLB_B[3]_9 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_9 NWGSEL_B_9
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_9 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[23] BLB_A[0]_8 BLB_A[1]_8 BLB_A[2]_8 BLB_A[3]_8 BLB_B[0]_8 BLB_B[1]_8
+  BLB_B[2]_8 BLB_B[3]_8 DATAIN_A_8 DATAIN_B_8 GDL_A_8 GDL_B_8 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_8 NBLB_A[1]_8 NBLB_A[2]_8
+  NBLB_A[3]_8 NBLB_B[0]_8 NBLB_B[1]_8 NBLB_B[2]_8 NBLB_B[3]_8 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_8 NWGSEL_B_8
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_8 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[24] BLB_A[0]_7 BLB_A[1]_7 BLB_A[2]_7 BLB_A[3]_7 BLB_B[0]_7 BLB_B[1]_7
+  BLB_B[2]_7 BLB_B[3]_7 DATAIN_A_7 DATAIN_B_7 GDL_A_7 GDL_B_7 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_7 NBLB_A[1]_7 NBLB_A[2]_7
+  NBLB_A[3]_7 NBLB_B[0]_7 NBLB_B[1]_7 NBLB_B[2]_7 NBLB_B[3]_7 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_7 NWGSEL_B_7
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_7 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[25] BLB_A[0]_6 BLB_A[1]_6 BLB_A[2]_6 BLB_A[3]_6 BLB_B[0]_6 BLB_B[1]_6
+  BLB_B[2]_6 BLB_B[3]_6 DATAIN_A_6 DATAIN_B_6 GDL_A_6 GDL_B_6 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_6 NBLB_A[1]_6 NBLB_A[2]_6
+  NBLB_A[3]_6 NBLB_B[0]_6 NBLB_B[1]_6 NBLB_B[2]_6 NBLB_B[3]_6 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_6 NWGSEL_B_6
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_6 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[26] BLB_A[0]_5 BLB_A[1]_5 BLB_A[2]_5 BLB_A[3]_5 BLB_B[0]_5 BLB_B[1]_5
+  BLB_B[2]_5 BLB_B[3]_5 DATAIN_A_5 DATAIN_B_5 GDL_A_5 GDL_B_5 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_5 NBLB_A[1]_5 NBLB_A[2]_5
+  NBLB_A[3]_5 NBLB_B[0]_5 NBLB_B[1]_5 NBLB_B[2]_5 NBLB_B[3]_5 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_5 NWGSEL_B_5
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_5 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[27] BLB_A[0]_4 BLB_A[1]_4 BLB_A[2]_4 BLB_A[3]_4 BLB_B[0]_4 BLB_B[1]_4
+  BLB_B[2]_4 BLB_B[3]_4 DATAIN_A_4 DATAIN_B_4 GDL_A_4 GDL_B_4 NACT_B
+  NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_4 NBLB_A[1]_4 NBLB_A[2]_4
+  NBLB_A[3]_4 NBLB_B[0]_4 NBLB_B[1]_4 NBLB_B[2]_4 NBLB_B[3]_4 NDSA_TP_A
+  NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1]
+  NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_4 NWGSEL_B_4
+  NWSEL_A[0] NWSEL_A[1] NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1]
+  NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO
+  SA_TP_A SA_TP_B VDDCE_4 VDDPE VNWC VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[4] BLB_A[0]_27 BLB_A[1]_27 BLB_A[2]_27 BLB_A[3]_27 BLB_B[0]_27
+  BLB_B[1]_27 BLB_B[2]_27 BLB_B[3]_27 DATAIN_A_27 DATAIN_B_27 GDL_A_27
+  GDL_B_27 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_27 NBLB_A[1]_27
+  NBLB_A[2]_27 NBLB_A[3]_27 NBLB_B[0]_27 NBLB_B[1]_27 NBLB_B[2]_27
+  NBLB_B[3]_27 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_27 NWGSEL_B_27 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_27 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[5] BLB_A[0]_26 BLB_A[1]_26 BLB_A[2]_26 BLB_A[3]_26 BLB_B[0]_26
+  BLB_B[1]_26 BLB_B[2]_26 BLB_B[3]_26 DATAIN_A_26 DATAIN_B_26 GDL_A_26
+  GDL_B_26 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_26 NBLB_A[1]_26
+  NBLB_A[2]_26 NBLB_A[3]_26 NBLB_B[0]_26 NBLB_B[1]_26 NBLB_B[2]_26
+  NBLB_B[3]_26 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_26 NWGSEL_B_26 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_26 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[6] BLB_A[0]_25 BLB_A[1]_25 BLB_A[2]_25 BLB_A[3]_25 BLB_B[0]_25
+  BLB_B[1]_25 BLB_B[2]_25 BLB_B[3]_25 DATAIN_A_25 DATAIN_B_25 GDL_A_25
+  GDL_B_25 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_25 NBLB_A[1]_25
+  NBLB_A[2]_25 NBLB_A[3]_25 NBLB_B[0]_25 NBLB_B[1]_25 NBLB_B[2]_25
+  NBLB_B[3]_25 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_25 NWGSEL_B_25 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_25 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[7] BLB_A[0]_24 BLB_A[1]_24 BLB_A[2]_24 BLB_A[3]_24 BLB_B[0]_24
+  BLB_B[1]_24 BLB_B[2]_24 BLB_B[3]_24 DATAIN_A_24 DATAIN_B_24 GDL_A_24
+  GDL_B_24 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_24 NBLB_A[1]_24
+  NBLB_A[2]_24 NBLB_A[3]_24 NBLB_B[0]_24 NBLB_B[1]_24 NBLB_B[2]_24
+  NBLB_B[3]_24 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_24 NWGSEL_B_24 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_24 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[8] BLB_A[0]_23 BLB_A[1]_23 BLB_A[2]_23 BLB_A[3]_23 BLB_B[0]_23
+  BLB_B[1]_23 BLB_B[2]_23 BLB_B[3]_23 DATAIN_A_23 DATAIN_B_23 GDL_A_23
+  GDL_B_23 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_23 NBLB_A[1]_23
+  NBLB_A[2]_23 NBLB_A[3]_23 NBLB_B[0]_23 NBLB_B[1]_23 NBLB_B[2]_23
+  NBLB_B[3]_23 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_23 NWGSEL_B_23 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_23 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
XCMUXSA[9] BLB_A[0]_22 BLB_A[1]_22 BLB_A[2]_22 BLB_A[3]_22 BLB_B[0]_22
+  BLB_B[1]_22 BLB_B[2]_22 BLB_B[3]_22 DATAIN_A_22 DATAIN_B_22 GDL_A_22
+  GDL_B_22 NACT_B NACT_FDBK_B NACT_FDBK_T NACT_T NBLB_A[0]_22 NBLB_A[1]_22
+  NBLB_A[2]_22 NBLB_A[3]_22 NBLB_B[0]_22 NBLB_B[1]_22 NBLB_B[2]_22
+  NBLB_B[3]_22 NDSA_TP_A NDSA_TP_B NRSEL_A[0] NRSEL_A[1] NRSEL_A[2]
+  NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3] NWCLK_WT_A
+  NWCLK_WT_B NWGSEL_A_22 NWGSEL_B_22 NWSEL_A[0] NWSEL_A[1] NWSEL_A[2]
+  NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B RDA_OVRDB RDB_OVRDB SA_TIELO SA_TP_A SA_TP_B VDDCE_22 VDDPE VNWC
+  VDDPE VPW VPW SRAMdpw64d256CMUXSA
.ENDS SRAMdpw64d256COLMX0DN32O
****
.SUBCKT SRAMdpw64d256TIMER ACTCLMP_A ACTCLMP_B BNK_A BNK_B CA_A[0] CA_A[1]
+  CA_B[0] CA_B[1] CLK_A CLK_B DBL_A DBL_B IACTCLMP_A IACTCLMP_B LOG0_DBL_A
+  LOG0_DBL_B NACT NACT_FDBK_LB NACT_FDBK_LT NACT_FDBK_RB NACT_FDBK_RT NACT_LB
+  NACT_LT NACT_RB NACT_RT NDFTRAMBYP_A NDFTRAMBYP_B NDSA_TP_A NDSA_TP_B
+  NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NRSEL_A[0] NRSEL_A[1]
+  NRSEL_A[2] NRSEL_A[3] NRSEL_B[0] NRSEL_B[1] NRSEL_B[2] NRSEL_B[3]
+  NWCLK_WT_A NWCLK_WT_B NWL_CLKB_A NWL_CLKB_B NWSEL_A[0] NWSEL_A[1]
+  NWSEL_A[2] NWSEL_A[3] NWSEL_B[0] NWSEL_B[1] NWSEL_B[2] NWSEL_B[3]
+  NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3]
+  PCH_BL_LB_A PCH_BL_LB_B PCH_BL_RB_A PCH_BL_RB_B RDA_OVRDB RDB_OVRDB RETA[0]
+  RETA[1] RETB[0] RETB[1] RE_A RE_B SA_TIELO SA_TP_A SA_TP_B VDDCA VDDCB
+  VDDCE VDDPE VNWC VNWP VPW VSSE WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256TIMER: 543 flat devices **
X_MIbuf_act_a.I2.MXNA1 ACTCLMP_A IBUF_ACT_A.NA VSSE VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MIbuf_act_a.I2.MXPA1 ACTCLMP_A IBUF_ACT_A.NA VDDPE VNWP P11LL_CKT W=3.98U
+  L=0.04U
X_MIbuf_act_a.I5.MXNA1 IBUF_ACT_A.NA IACTCLMP_A VSSE VPW N11LL_CKT W=0.5U
+  L=0.04U
X_MIbuf_act_a.I5.MXPA1 IBUF_ACT_A.NA IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.995U
+  L=0.04U
X_MIbuf_act_b.I2.MXNA1 ACTCLMP_B IBUF_ACT_B.NA VSSE VPW N11LL_CKT W=1.99U
+  L=0.04U
X_MIbuf_act_b.I2.MXPA1 ACTCLMP_B IBUF_ACT_B.NA VDDPE VNWP P11LL_CKT W=3.98U
+  L=0.04U
X_MIbuf_act_b.I5.MXNA1 IBUF_ACT_B.NA IACTCLMP_B VSSE VPW N11LL_CKT W=0.5U
+  L=0.04U
X_MIbuf_act_b.I5.MXPA1 IBUF_ACT_B.NA IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.995U
+  L=0.04U
X_MIbufa_0.I2.MXNA1 NACT_LB IBUFA_0.NA VSSE VPW N11LL_CKT W=1.99U L=0.04U
X_MIbufa_0.I2.MXPA1 NACT_LB IBUFA_0.NA VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MIbufa_0.I5.MXNA1 IBUFA_0.NA RETA[0] VSSE VPW N11LL_CKT W=0.43U L=0.04U
X_MIbufa_0.I5.MXPA1 IBUFA_0.NA RETA[0] VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MIbufa_1.I2.MXNA1 NACT_LT IBUFA_1.NA VSSE VPW N11LL_CKT W=1.99U L=0.04U
X_MIbufa_1.I2.MXPA1 NACT_LT IBUFA_1.NA VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MIbufa_1.I5.MXNA1 IBUFA_1.NA NACT_FDBK_RB VSSE VPW N11LL_CKT W=0.43U L=0.04U
X_MIbufa_1.I5.MXPA1 IBUFA_1.NA NACT_FDBK_RB VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_MIbufb_0.I2.MXNA1 NACT_RB IBUFB_0.NA VSSE VPW N11LL_CKT W=1.99U L=0.04U
X_MIbufb_0.I2.MXPA1 NACT_RB IBUFB_0.NA VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MIbufb_0.I5.MXNA1 IBUFB_0.NA NACT_FDBK_LB VSSE VPW N11LL_CKT W=0.43U L=0.04U
X_MIbufb_0.I5.MXPA1 IBUFB_0.NA NACT_FDBK_LB VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_MIbufb_1.I2.MXNA1 NACT_RT IBUFB_1.NA VSSE VPW N11LL_CKT W=1.99U L=0.04U
X_MIbufb_1.I2.MXPA1 NACT_RT IBUFB_1.NA VDDPE VNWP P11LL_CKT W=2.84U L=0.04U
X_MIbufb_1.I5.MXNA1 IBUFB_1.NA NACT_FDBK_LT VSSE VPW N11LL_CKT W=0.43U L=0.04U
X_MIbufb_1.I5.MXPA1 IBUFB_1.NA NACT_FDBK_LT VDDPE VNWP P11LL_CKT W=0.85U
+  L=0.04U
X_MIcollovrd.I22.MXNA1 ICOLLOVRD.CLKA_BOT_I NWL_CLKB_A VSSE VPW N11LL_CKT
+  W=0.49U L=0.04U
X_MIcollovrd.I22.MXPA1 ICOLLOVRD.CLKA_BOT_I NWL_CLKB_A VDDPE VNWP P11LL_CKT
+  W=1.19U L=0.04U
X_MIcollovrd.I24.MXNA1 ICOLLOVRD.CLKB_BOT_I NWL_CLKB_B VSSE VPW N11LL_CKT
+  W=0.49U L=0.04U
X_MIcollovrd.I24.MXPA1 ICOLLOVRD.CLKB_BOT_I NWL_CLKB_B VDDPE VNWP P11LL_CKT
+  W=1.19U L=0.04U
X_MIcollovrd.I40.MXNA1 RDA_OVRDB ICOLLOVRD.RDA_OVRDB_N VSSE VPW N11LL_CKT
+  W=4.26U L=0.04U
X_MIcollovrd.I40.MXPA1 RDA_OVRDB ICOLLOVRD.RDA_OVRDB_N VDDPE VNWP P11LL_CKT
+  W=8.52U L=0.04U
X_MIcollovrd.I41.MXNA1 RDB_OVRDB ICOLLOVRD.RDB_OVRDB_N VSSE VPW N11LL_CKT
+  W=4.26U L=0.04U
X_MIcollovrd.I41.MXPA1 RDB_OVRDB ICOLLOVRD.RDB_OVRDB_N VDDPE VNWP P11LL_CKT
+  W=8.52U L=0.04U
X_MIcollovrd.MXN13 ICOLLOVRD.RDA_OVRDB_N WRB_MA ICOLLOVRD.CLKAB_NB VPW
+  N11LL_CKT W=1.79U L=0.04U
X_MIcollovrd.MXN14 ICOLLOVRD.RDB_OVRDB_N WRA_MA ICOLLOVRD.CLKAB_NB VPW
+  N11LL_CKT W=1.79U L=0.04U
X_MIcollovrd.MXN6 ICOLLOVRD.NET116 ICOLLOVRD.CLKA_BOT_I VSSE VPW N11LL_CKT
+  W=2.09U L=0.04U
X_MIcollovrd.MXN7 ICOLLOVRD.CLKAB_NB ICOLLOVRD.CLKB_BOT_I ICOLLOVRD.NET116 VPW
+  N11LL_CKT W=2.09U L=0.04U
X_MIcollovrd.MXP10 ICOLLOVRD.RDA_OVRDB_N ICOLLOVRD.CLKA_BOT_I VDDPE VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcollovrd.MXP11 ICOLLOVRD.RDA_OVRDB_N ICOLLOVRD.CLKB_BOT_I VDDPE VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcollovrd.MXP12 ICOLLOVRD.RDB_OVRDB_N ICOLLOVRD.CLKB_BOT_I VDDPE VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcollovrd.MXP13 ICOLLOVRD.RDB_OVRDB_N ICOLLOVRD.CLKA_BOT_I VDDPE VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIcollovrd.MXP14 ICOLLOVRD.RDB_OVRDB_N WRA_MA VDDPE VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_MIcollovrd.MXP9 ICOLLOVRD.RDA_OVRDB_N WRB_MA VDDPE VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.I10.MXNA1 ITIMERA.BNK_N BNK_A VSSE VPW N11LL_CKT W=0.36U L=0.04U
X_MItimera.I10.MXPA1 ITIMERA.BNK_N BNK_A VDDPE VNWP P11LL_CKT W=0.72U L=0.04U
X_MItimera.Ick_bot.I20.MXNA1 ITIMERA.ICK_BOT.BNK_RW ITIMERA.ICK_BOT.BNK_RW_N
+  VSSE VPW N11LL_CKT W=3.2U L=0.04U
X_MItimera.Ick_bot.I20.MXPA1 ITIMERA.ICK_BOT.BNK_RW ITIMERA.ICK_BOT.BNK_RW_N
+  VDDPE VNWP P11LL_CKT W=5.68U L=0.04U
X_MItimera.Ick_bot.I23.MXNA1 ITIMERA.ICK_BOT.BNK_RW_N ITIMERA.BNK_N
+  ITIMERA.ICK_BOT.I23.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_MItimera.Ick_bot.I23.MXNA2 ITIMERA.ICK_BOT.I23.N1 NDFTRAMBYP_A VSSE VPW
+  N11LL_CKT W=1.42U L=0.04U
X_MItimera.Ick_bot.I23.MXPA1 ITIMERA.ICK_BOT.BNK_RW_N ITIMERA.BNK_N VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MItimera.Ick_bot.I23.MXPA2 ITIMERA.ICK_BOT.BNK_RW_N NDFTRAMBYP_A VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MItimera.Ick_bot.I47.MXNA1 NWL_CLKB_A CLK_A ITIMERA.ICK_BOT.I47.N1 VPW
+  N11LL_CKT W=3.56U L=0.04U
X_MItimera.Ick_bot.I47.MXNA2 ITIMERA.ICK_BOT.I47.N1 ITIMERA.ICK_BOT.BNK_RW
+  VSSE VPW N11LL_CKT W=3.56U L=0.04U
X_MItimera.Ick_bot.I47.MXPA1 NWL_CLKB_A CLK_A VDDPE VNWP P11LL_CKT W=2.38U
+  L=0.04U
X_MItimera.Ick_bot.I47.MXPA2 NWL_CLKB_A ITIMERA.ICK_BOT.BNK_RW VDDPE VNWP
+  P11LL_CKT W=2.38U L=0.04U
X_MItimera.Ick_bot.Itmrnd2.I47.MXNA1 NWL_CLKB_A CLK_A
+  ITIMERA.ICK_BOT.ITMRND2.I47.N1 VPW N11LL_CKT W=11.36U L=0.04U
X_MItimera.Ick_bot.Itmrnd2.I47.MXNA2 ITIMERA.ICK_BOT.ITMRND2.I47.N1
+  ITIMERA.ICK_BOT.BNK_RW VSSE VPW N11LL_CKT W=14.24U L=0.04U
X_MItimera.Ick_bot.Itmrnd2.I47.MXPA1 NWL_CLKB_A CLK_A VDDPE VNWP P11LL_CKT
+  W=6.8U L=0.04U
X_MItimera.Ick_bot.Itmrnd2.I47.MXPA2 NWL_CLKB_A ITIMERA.ICK_BOT.BNK_RW VDDPE
+  VNWP P11LL_CKT W=6.8U L=0.04U
X_MItimera.Icol_dec.I0_0.MXNA1 ITIMERA.ICOL_DEC.COL_SEL_N[0]
+  ITIMERA.ICOL_DEC.SEL2_N ITIMERA.ICOL_DEC.I0_0.N1 VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MItimera.Icol_dec.I0_0.MXNA2 ITIMERA.ICOL_DEC.I0_0.N1
+  ITIMERA.ICOL_DEC.SEL1_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_0.MXPA1 ITIMERA.ICOL_DEC.COL_SEL_N[0]
+  ITIMERA.ICOL_DEC.SEL2_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_0.MXPA2 ITIMERA.ICOL_DEC.COL_SEL_N[0]
+  ITIMERA.ICOL_DEC.SEL1_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_1.MXNA1 ITIMERA.ICOL_DEC.COL_SEL_N[1]
+  ITIMERA.ICOL_DEC.SEL2_N ITIMERA.ICOL_DEC.I0_1.N1 VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MItimera.Icol_dec.I0_1.MXNA2 ITIMERA.ICOL_DEC.I0_1.N1 CA_A[0] VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_1.MXPA1 ITIMERA.ICOL_DEC.COL_SEL_N[1]
+  ITIMERA.ICOL_DEC.SEL2_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_1.MXPA2 ITIMERA.ICOL_DEC.COL_SEL_N[1] CA_A[0] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_2.MXNA1 ITIMERA.ICOL_DEC.COL_SEL_N[2] CA_A[1]
+  ITIMERA.ICOL_DEC.I0_2.N1 VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_2.MXNA2 ITIMERA.ICOL_DEC.I0_2.N1
+  ITIMERA.ICOL_DEC.SEL1_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_2.MXPA1 ITIMERA.ICOL_DEC.COL_SEL_N[2] CA_A[1] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_2.MXPA2 ITIMERA.ICOL_DEC.COL_SEL_N[2]
+  ITIMERA.ICOL_DEC.SEL1_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_3.MXNA1 ITIMERA.ICOL_DEC.COL_SEL_N[3] CA_A[1]
+  ITIMERA.ICOL_DEC.I0_3.N1 VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_3.MXNA2 ITIMERA.ICOL_DEC.I0_3.N1 CA_A[0] VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_3.MXPA1 ITIMERA.ICOL_DEC.COL_SEL_N[3] CA_A[1] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I0_3.MXPA2 ITIMERA.ICOL_DEC.COL_SEL_N[3] CA_A[0] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I11_0.MXNA1 ITIMERA.ICOL_DEC.SEL1_N CA_A[0] VSSE VPW
+  N11LL_CKT W=0.205U L=0.04U
X_MItimera.Icol_dec.I11_0.MXPA1 ITIMERA.ICOL_DEC.SEL1_N CA_A[0] VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_MItimera.Icol_dec.I11_1.MXNA1 ITIMERA.ICOL_DEC.SEL2_N CA_A[1] VSSE VPW
+  N11LL_CKT W=0.205U L=0.04U
X_MItimera.Icol_dec.I11_1.MXPA1 ITIMERA.ICOL_DEC.SEL2_N CA_A[1] VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_MItimera.Icol_dec.I13.MXNA1 ITIMERA.ICOL_DEC.CLK_BOT_I NWL_CLKB_A VSSE VPW
+  N11LL_CKT W=0.695U L=0.04U
X_MItimera.Icol_dec.I13.MXPA1 ITIMERA.ICOL_DEC.CLK_BOT_I NWL_CLKB_A VDDPE VNWP
+  P11LL_CKT W=1.2U L=0.04U
X_MItimera.Icol_dec.I15.MXNA1 ITIMERA.ICOL_DEC.NRE RE_A VSSE VPW N11LL_CKT
+  W=0.3U L=0.04U
X_MItimera.Icol_dec.I15.MXPA1 ITIMERA.ICOL_DEC.NRE RE_A VDDPE VNWP P11LL_CKT
+  W=0.595U L=0.04U
X_MItimera.Icol_dec.I17.MXNA1 ITIMERA.ICOL_DEC.BRE ITIMERA.ICOL_DEC.NRE VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MItimera.Icol_dec.I17.MXPA1 ITIMERA.ICOL_DEC.BRE ITIMERA.ICOL_DEC.NRE VDDPE
+  VNWP P11LL_CKT W=0.595U L=0.04U
X_MItimera.Icol_dec.I18.MXNA1 ITIMERA.ICOL_DEC.NWE WE_A VSSE VPW N11LL_CKT
+  W=0.3U L=0.04U
X_MItimera.Icol_dec.I18.MXPA1 ITIMERA.ICOL_DEC.NWE WE_A VDDPE VNWP P11LL_CKT
+  W=0.595U L=0.04U
X_MItimera.Icol_dec.I20.MXNA1 ITIMERA.ICOL_DEC.BWE ITIMERA.ICOL_DEC.NWE VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MItimera.Icol_dec.I20.MXPA1 ITIMERA.ICOL_DEC.BWE ITIMERA.ICOL_DEC.NWE VDDPE
+  VNWP P11LL_CKT W=0.595U L=0.04U
X_MItimera.Icol_dec.I21_0.MXNA1 ITIMERA.ICOL_DEC.COL_SEL[0]
+  ITIMERA.ICOL_DEC.COL_SEL_N[0] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I21_0.MXPA1 ITIMERA.ICOL_DEC.COL_SEL[0]
+  ITIMERA.ICOL_DEC.COL_SEL_N[0] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimera.Icol_dec.I21_1.MXNA1 ITIMERA.ICOL_DEC.COL_SEL[1]
+  ITIMERA.ICOL_DEC.COL_SEL_N[1] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I21_1.MXPA1 ITIMERA.ICOL_DEC.COL_SEL[1]
+  ITIMERA.ICOL_DEC.COL_SEL_N[1] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimera.Icol_dec.I21_2.MXNA1 ITIMERA.ICOL_DEC.COL_SEL[2]
+  ITIMERA.ICOL_DEC.COL_SEL_N[2] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I21_2.MXPA1 ITIMERA.ICOL_DEC.COL_SEL[2]
+  ITIMERA.ICOL_DEC.COL_SEL_N[2] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimera.Icol_dec.I21_3.MXNA1 ITIMERA.ICOL_DEC.COL_SEL[3]
+  ITIMERA.ICOL_DEC.COL_SEL_N[3] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Icol_dec.I21_3.MXPA1 ITIMERA.ICOL_DEC.COL_SEL[3]
+  ITIMERA.ICOL_DEC.COL_SEL_N[3] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I5.MXNA1 ITIMERA.ICOL_DEC.IBOT_0.RSEL
+  ITIMERA.ICOL_DEC.IBOT_0.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I5.MXPA1 ITIMERA.ICOL_DEC.IBOT_0.RSEL
+  ITIMERA.ICOL_DEC.IBOT_0.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I6.MXNA1 NWSEL_A[0] ITIMERA.ICOL_DEC.IBOT_0.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I6.MXPA1 NWSEL_A[0] ITIMERA.ICOL_DEC.IBOT_0.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I7.MXNA1 ITIMERA.ICOL_DEC.IBOT_0.WSEL
+  ITIMERA.ICOL_DEC.IBOT_0.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I7.MXPA1 ITIMERA.ICOL_DEC.IBOT_0.WSEL
+  ITIMERA.ICOL_DEC.IBOT_0.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I8.MXNA1 NRSEL_A[0] ITIMERA.ICOL_DEC.IBOT_0.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimera.Icol_dec.Ibot_0.I8.MXPA1 NRSEL_A[0] ITIMERA.ICOL_DEC.IBOT_0.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXN0 ITIMERA.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[0] ITIMERA.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXN1 ITIMERA.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[0] ITIMERA.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXP0 ITIMERA.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERA.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXP1 ITIMERA.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXP2 ITIMERA.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXP3 ITIMERA.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERA.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXP4 ITIMERA.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[0] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_0.MXP6 ITIMERA.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[0] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I5.MXNA1 ITIMERA.ICOL_DEC.IBOT_1.RSEL
+  ITIMERA.ICOL_DEC.IBOT_1.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I5.MXPA1 ITIMERA.ICOL_DEC.IBOT_1.RSEL
+  ITIMERA.ICOL_DEC.IBOT_1.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I6.MXNA1 NWSEL_A[1] ITIMERA.ICOL_DEC.IBOT_1.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I6.MXPA1 NWSEL_A[1] ITIMERA.ICOL_DEC.IBOT_1.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I7.MXNA1 ITIMERA.ICOL_DEC.IBOT_1.WSEL
+  ITIMERA.ICOL_DEC.IBOT_1.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I7.MXPA1 ITIMERA.ICOL_DEC.IBOT_1.WSEL
+  ITIMERA.ICOL_DEC.IBOT_1.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I8.MXNA1 NRSEL_A[1] ITIMERA.ICOL_DEC.IBOT_1.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimera.Icol_dec.Ibot_1.I8.MXPA1 NRSEL_A[1] ITIMERA.ICOL_DEC.IBOT_1.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXN0 ITIMERA.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[1] ITIMERA.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXN1 ITIMERA.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[1] ITIMERA.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXP0 ITIMERA.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERA.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXP1 ITIMERA.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXP2 ITIMERA.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXP3 ITIMERA.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERA.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXP4 ITIMERA.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_1.MXP6 ITIMERA.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I5.MXNA1 ITIMERA.ICOL_DEC.IBOT_2.RSEL
+  ITIMERA.ICOL_DEC.IBOT_2.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I5.MXPA1 ITIMERA.ICOL_DEC.IBOT_2.RSEL
+  ITIMERA.ICOL_DEC.IBOT_2.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I6.MXNA1 NWSEL_A[2] ITIMERA.ICOL_DEC.IBOT_2.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I6.MXPA1 NWSEL_A[2] ITIMERA.ICOL_DEC.IBOT_2.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I7.MXNA1 ITIMERA.ICOL_DEC.IBOT_2.WSEL
+  ITIMERA.ICOL_DEC.IBOT_2.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I7.MXPA1 ITIMERA.ICOL_DEC.IBOT_2.WSEL
+  ITIMERA.ICOL_DEC.IBOT_2.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I8.MXNA1 NRSEL_A[2] ITIMERA.ICOL_DEC.IBOT_2.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimera.Icol_dec.Ibot_2.I8.MXPA1 NRSEL_A[2] ITIMERA.ICOL_DEC.IBOT_2.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXN0 ITIMERA.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[2] ITIMERA.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXN1 ITIMERA.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[2] ITIMERA.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXP0 ITIMERA.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERA.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXP1 ITIMERA.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXP2 ITIMERA.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXP3 ITIMERA.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERA.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXP4 ITIMERA.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[2] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_2.MXP6 ITIMERA.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[2] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I5.MXNA1 ITIMERA.ICOL_DEC.IBOT_3.RSEL
+  ITIMERA.ICOL_DEC.IBOT_3.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I5.MXPA1 ITIMERA.ICOL_DEC.IBOT_3.RSEL
+  ITIMERA.ICOL_DEC.IBOT_3.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I6.MXNA1 NWSEL_A[3] ITIMERA.ICOL_DEC.IBOT_3.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I6.MXPA1 NWSEL_A[3] ITIMERA.ICOL_DEC.IBOT_3.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I7.MXNA1 ITIMERA.ICOL_DEC.IBOT_3.WSEL
+  ITIMERA.ICOL_DEC.IBOT_3.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I7.MXPA1 ITIMERA.ICOL_DEC.IBOT_3.WSEL
+  ITIMERA.ICOL_DEC.IBOT_3.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I8.MXNA1 NRSEL_A[3] ITIMERA.ICOL_DEC.IBOT_3.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimera.Icol_dec.Ibot_3.I8.MXPA1 NRSEL_A[3] ITIMERA.ICOL_DEC.IBOT_3.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXN0 ITIMERA.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[3] ITIMERA.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXN1 ITIMERA.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[3] ITIMERA.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXP0 ITIMERA.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERA.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXP1 ITIMERA.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXP2 ITIMERA.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERA.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXP3 ITIMERA.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERA.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXP4 ITIMERA.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[3] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.Ibot_3.MXP6 ITIMERA.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERA.ICOL_DEC.COL_SEL[3] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimera.Icol_dec.MXN3 ITIMERA.ICOL_DEC.NET81 ITIMERA.ICOL_DEC.CLK_BOT_I
+  VSSE VPW N11LL_CKT W=2.08U L=0.04U
X_MItimera.Icol_dec.MXN4 ITIMERA.ICOL_DEC.NET86 ITIMERA.ICOL_DEC.BWE
+  ITIMERA.ICOL_DEC.NET81 VPW N11LL_CKT W=1.04U L=0.04U
X_MItimera.Icol_dec.MXN5 ITIMERA.ICOL_DEC.NET82 ITIMERA.ICOL_DEC.BRE
+  ITIMERA.ICOL_DEC.NET81 VPW N11LL_CKT W=1.04U L=0.04U
X_MItimera.Isatimer.I103.MXN12 ITIMERA.ISATIMER.SCLKD[0]
+  ITIMERA.ISATIMER.I103.DI1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I103.MXN3 ITIMERA.ISATIMER.I103.NET22 NWL_CLKB_A VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I103.MXN4 ITIMERA.ISATIMER.I103.DI1
+  ITIMERA.ISATIMER.I103.NDI VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I103.MXN8 ITIMERA.ISATIMER.I103.NDI NWL_CLKB_A
+  ITIMERA.ISATIMER.I103.NET22 VPW N11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I103.MXP0 ITIMERA.ISATIMER.I103.NDI NWL_CLKB_A VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I103.MXP1 ITIMERA.ISATIMER.I103.DI1
+  ITIMERA.ISATIMER.I103.NDI VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I103.MXP3 ITIMERA.ISATIMER.SCLKD[0]
+  ITIMERA.ISATIMER.I103.DI1 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.I47.MXNA1 ITIMERA.ISATIMER.SB1 ITIMERA.ISATIMER.CLK_RD_N
+  ITIMERA.ISATIMER.I47.N1 VPW N11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.I47.MXNA2 ITIMERA.ISATIMER.I47.N1 ITIMERA.ISATIMER.NET97
+  VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.I47.MXPA1 ITIMERA.ISATIMER.SB1 ITIMERA.ISATIMER.CLK_RD_N
+  VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.I47.MXPA2 ITIMERA.ISATIMER.SB1 ITIMERA.ISATIMER.NET97
+  VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.I66.MXNA1 NDSA_TP_A ITIMERA.ISATIMER.SB2 VSSE VPW
+  N11LL_CKT W=5.97U L=0.04U
X_MItimera.Isatimer.I66.MXPA1 NDSA_TP_A ITIMERA.ISATIMER.SB2 VDDPE VNWP
+  P11LL_CKT W=11.91U L=0.04U
X_MItimera.Isatimer.I71.MXNA1 ITIMERA.ISATIMER.SB2 ITIMERA.ISATIMER.SB1 VSSE
+  VPW N11LL_CKT W=1.59U L=0.04U
X_MItimera.Isatimer.I71.MXPA1 ITIMERA.ISATIMER.SB2 ITIMERA.ISATIMER.SB1 VDDPE
+  VNWP P11LL_CKT W=3.18U L=0.04U
X_MItimera.Isatimer.I72.MXNA1 SA_TP_A ITIMERA.ISATIMER.SA1 VSSE VPW N11LL_CKT
+  W=7.2U L=0.04U
X_MItimera.Isatimer.I72.MXPA1 SA_TP_A ITIMERA.ISATIMER.SA1 VDDPE VNWP
+  P11LL_CKT W=16.9U L=0.04U
X_MItimera.Isatimer.I74.MXNA1 ITIMERA.ISATIMER.CLK_WTE_N CLK_A
+  ITIMERA.ISATIMER.I74.N1 VPW N11LL_CKT W=1.52U L=0.04U
X_MItimera.Isatimer.I74.MXNA2 ITIMERA.ISATIMER.I74.N1 WTE_A VSSE VPW N11LL_CKT
+  W=1.52U L=0.04U
X_MItimera.Isatimer.I74.MXPA1 ITIMERA.ISATIMER.CLK_WTE_N CLK_A VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_MItimera.Isatimer.I74.MXPA2 ITIMERA.ISATIMER.CLK_WTE_N WTE_A VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_MItimera.Isatimer.I75.MXNA1 ITIMERA.ISATIMER.CLK_RD_N CLK_A
+  ITIMERA.ISATIMER.I75.N2 VPW N11LL_CKT W=3U L=0.04U
X_MItimera.Isatimer.I75.MXNA2 ITIMERA.ISATIMER.I75.N2 NDFTRAMBYP_A
+  ITIMERA.ISATIMER.I75.N1 VPW N11LL_CKT W=3U L=0.04U
X_MItimera.Isatimer.I75.MXNA3 ITIMERA.ISATIMER.I75.N1 RE_A VSSE VPW N11LL_CKT
+  W=3U L=0.04U
X_MItimera.Isatimer.I75.MXPA1 ITIMERA.ISATIMER.CLK_RD_N CLK_A VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_MItimera.Isatimer.I75.MXPA2 ITIMERA.ISATIMER.CLK_RD_N NDFTRAMBYP_A VDDPE
+  VNWP P11LL_CKT W=1.99U L=0.04U
X_MItimera.Isatimer.I75.MXPA3 ITIMERA.ISATIMER.CLK_RD_N RE_A VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_MItimera.Isatimer.I76.MXNA1 ITIMERA.ISATIMER.SA1 ITIMERA.ISATIMER.CLK_RD_N
+  VSSE VPW N11LL_CKT W=1.59U L=0.04U
X_MItimera.Isatimer.I76.MXPA1 ITIMERA.ISATIMER.SA1 ITIMERA.ISATIMER.CLK_RD_N
+  VDDPE VNWP P11LL_CKT W=3.18U L=0.04U
X_MItimera.Isatimer.I77.MXNA1 ITIMERA.ISATIMER.CLK_WTE
+  ITIMERA.ISATIMER.CLK_WTE_N VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_MItimera.Isatimer.I77.MXPA1 ITIMERA.ISATIMER.CLK_WTE
+  ITIMERA.ISATIMER.CLK_WTE_N VDDPE VNWP P11LL_CKT W=1.86U L=0.04U
X_MItimera.Isatimer.I78.MXNA1 NWCLK_WT_A ITIMERA.ISATIMER.CLK_WTE VSSE VPW
+  N11LL_CKT W=4.25U L=0.04U
X_MItimera.Isatimer.I78.MXPA1 NWCLK_WT_A ITIMERA.ISATIMER.CLK_WTE VDDPE VNWP
+  P11LL_CKT W=4.25U L=0.04U
X_MItimera.Isatimer.I80.MXNA1 ITIMERA.ISATIMER.RDT ITIMERA.ISATIMER.RDTNWE
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MItimera.Isatimer.I80.MXPA1 ITIMERA.ISATIMER.RDT ITIMERA.ISATIMER.RDTNWE
+  VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MItimera.Isatimer.I818_0.MXNA1 ITIMERA.ISATIMER.NET315[1]
+  ITIMERA.ISATIMER.SCLKD[0] VSSE VPW N11LL_CKT W=0.18U L=0.04U
X_MItimera.Isatimer.I818_0.MXNA2 ITIMERA.ISATIMER.NET315[1] RETA[0] VSSE VPW
+  N11LL_CKT W=0.18U L=0.04U
X_MItimera.Isatimer.I818_0.MXPA1 ITIMERA.ISATIMER.NET315[1]
+  ITIMERA.ISATIMER.SCLKD[0] ITIMERA.ISATIMER.I818_0.P1 VNWP P11LL_CKT W=0.52U
+  L=0.04U
X_MItimera.Isatimer.I818_0.MXPA2 ITIMERA.ISATIMER.I818_0.P1 RETA[0] VDDPE VNWP
+  P11LL_CKT W=0.52U L=0.04U
X_MItimera.Isatimer.I818_1.MXNA1 ITIMERA.ISATIMER.NET315[0]
+  ITIMERA.ISATIMER.SCLKD[0] VSSE VPW N11LL_CKT W=0.18U L=0.04U
X_MItimera.Isatimer.I818_1.MXNA2 ITIMERA.ISATIMER.NET315[0] NACT_FDBK_LB VSSE
+  VPW N11LL_CKT W=0.18U L=0.04U
X_MItimera.Isatimer.I818_1.MXPA1 ITIMERA.ISATIMER.NET315[0]
+  ITIMERA.ISATIMER.SCLKD[0] ITIMERA.ISATIMER.I818_1.P1 VNWP P11LL_CKT W=0.52U
+  L=0.04U
X_MItimera.Isatimer.I818_1.MXPA2 ITIMERA.ISATIMER.I818_1.P1 NACT_FDBK_LB VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_MItimera.Isatimer.I81_0.MXNA1 PCH_BL_LB_A ITIMERA.ISATIMER.NBLP[0] VSSE VPW
+  N11LL_CKT W=3.99U L=0.04U
X_MItimera.Isatimer.I81_0.MXPA1 PCH_BL_LB_A ITIMERA.ISATIMER.NBLP[0] VDDPE
+  VNWP P11LL_CKT W=5.25U L=0.04U
X_MItimera.Isatimer.I81_1.MXNA1 PCH_BL_RB_A ITIMERA.ISATIMER.NBLP[1] VSSE VPW
+  N11LL_CKT W=3.99U L=0.04U
X_MItimera.Isatimer.I81_1.MXPA1 PCH_BL_RB_A ITIMERA.ISATIMER.NBLP[1] VDDPE
+  VNWP P11LL_CKT W=5.25U L=0.04U
X_MItimera.Isatimer.I82.MXNA1 ITIMERA.ISATIMER.NET147 WE_A VSSE VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MItimera.Isatimer.I82.MXPA1 ITIMERA.ISATIMER.NET147 WE_A VDDPE VNWP
+  P11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I83.MXNA1 ITIMERA.ISATIMER.NET135 WE_B VSSE VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MItimera.Isatimer.I83.MXPA1 ITIMERA.ISATIMER.NET135 WE_B VDDPE VNWP
+  P11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I84.MXNA1 ITIMERA.ISATIMER.RDTNWE ITIMERA.ISATIMER.NET147
+  ITIMERA.ISATIMER.I84.N2 VPW N11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I84.MXNA2 ITIMERA.ISATIMER.I84.N2 ITIMERA.ISATIMER.NET135
+  ITIMERA.ISATIMER.I84.N1 VPW N11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I84.MXNA3 ITIMERA.ISATIMER.I84.N1 ITIMERA.ISATIMER.NET141
+  VSSE VPW N11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I84.MXPA1 ITIMERA.ISATIMER.RDTNWE ITIMERA.ISATIMER.NET147
+  VDDPE VNWP P11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I84.MXPA2 ITIMERA.ISATIMER.RDTNWE ITIMERA.ISATIMER.NET135
+  VDDPE VNWP P11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I84.MXPA3 ITIMERA.ISATIMER.RDTNWE ITIMERA.ISATIMER.NET141
+  VDDPE VNWP P11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.I85.MXNA1 ITIMERA.ISATIMER.NET141 NRDT_A VSSE VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MItimera.Isatimer.I85.MXPA1 ITIMERA.ISATIMER.NET141 NRDT_A VDDPE VNWP
+  P11LL_CKT W=0.29U L=0.04U
X_MItimera.Isatimer.Isa_dly.I54.MXNA1 ITIMERA.ISATIMER.ISA_DLY.A0
+  ITIMERA.ISATIMER.ISA_DLY.CK_D2 ITIMERA.ISATIMER.ISA_DLY.I54.N1 VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I54.MXNA2 ITIMERA.ISATIMER.ISA_DLY.I54.N1
+  ITIMERA.ISATIMER.ISA_DLY.CK_D2 VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I54.MXPA1 ITIMERA.ISATIMER.ISA_DLY.A0
+  ITIMERA.ISATIMER.ISA_DLY.CK_D2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I54.MXPA2 ITIMERA.ISATIMER.ISA_DLY.A0
+  ITIMERA.ISATIMER.ISA_DLY.CK_D2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I55.MXNA1 ITIMERA.ISATIMER.NET97
+  ITIMERA.ISATIMER.ISA_DLY.A0 ITIMERA.ISATIMER.ISA_DLY.I55.N1 VPW N11LL_CKT
+  W=0.795U L=0.04U
X_MItimera.Isatimer.Isa_dly.I55.MXNA2 ITIMERA.ISATIMER.ISA_DLY.I55.N1
+  ITIMERA.ISATIMER.ISA_DLY.A0 VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.Isa_dly.I55.MXPA1 ITIMERA.ISATIMER.NET97
+  ITIMERA.ISATIMER.ISA_DLY.A0 VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.Isa_dly.I55.MXPA2 ITIMERA.ISATIMER.NET97
+  ITIMERA.ISATIMER.ISA_DLY.A0 VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN0 ITIMERA.ISATIMER.ISA_DLY.I80.NET0137
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN11 ITIMERA.ISATIMER.ISA_DLY.I80.NET0141
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN12 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY_N
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY ITIMERA.ISATIMER.ISA_DLY.I80.NET0137 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN13 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2_N
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2 ITIMERA.ISATIMER.ISA_DLY.I80.NET0141
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN2 ITIMERA.ISATIMER.ISA_DLY.I80.NET104
+  ITIMERA.ISATIMER.CLK_RD_N VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN3 ITIMERA.ISATIMER.ISA_DLY.I80.D_N
+  ITIMERA.ISATIMER.CLK_RD_N ITIMERA.ISATIMER.ISA_DLY.I80.NET104 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN4 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN5 VSSE ITIMERA.ISATIMER.ISA_DLY.I80.D_N
+  VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN7 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXN8 ITIMERA.ISATIMER.ISA_DLY.CK_D1
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP0 ITIMERA.ISATIMER.ISA_DLY.I80.D_N
+  ITIMERA.ISATIMER.CLK_RD_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP1 ITIMERA.ISATIMER.ISA_DLY.I80.NET074
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP2 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY_N
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP3 ITIMERA.ISATIMER.ISA_DLY.I80.NET066
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY_N VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP5 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2_N
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP6 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_N ITIMERA.ISATIMER.ISA_DLY.I80.NET074 VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP7 ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY_N ITIMERA.ISATIMER.ISA_DLY.I80.NET066
+  VNWP P11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I80.MXP8 ITIMERA.ISATIMER.ISA_DLY.CK_D1
+  ITIMERA.ISATIMER.ISA_DLY.I80.D_DLY2_N VDDPE VNWP P11LL_CKT W=0.345U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN0 ITIMERA.ISATIMER.ISA_DLY.I81.NET066
+  ITIMERA.ISATIMER.ISA_DLY.CK_D1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN1 ITIMERA.ISATIMER.ISA_DLY.I81.D1_N
+  ITIMERA.ISATIMER.ISA_DLY.CK_D1 ITIMERA.ISATIMER.ISA_DLY.I81.NET066 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN2 ITIMERA.ISATIMER.ISA_DLY.I81.NET46
+  ITIMERA.ISATIMER.ISA_DLY.CK_D1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN3 ITIMERA.ISATIMER.ISA_DLY.I81.D_N
+  ITIMERA.ISATIMER.ISA_DLY.CK_D1 ITIMERA.ISATIMER.ISA_DLY.I81.NET46 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN4 ITIMERA.ISATIMER.ISA_DLY.CK_D2
+  ITIMERA.ISATIMER.ISA_DLY.I81.D_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN5 VSSE ITIMERA.ISATIMER.ISA_DLY.I81.D_N
+  VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN6 ITIMERA.ISATIMER.ISA_DLY.I81.D2
+  ITIMERA.ISATIMER.ISA_DLY.I81.D1_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXN7 VSSE ITIMERA.ISATIMER.ISA_DLY.I81.D1_N
+  VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXP0 ITIMERA.ISATIMER.ISA_DLY.I81.D_N
+  ITIMERA.ISATIMER.ISA_DLY.CK_D1 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXP1 ITIMERA.ISATIMER.ISA_DLY.CK_D2
+  ITIMERA.ISATIMER.ISA_DLY.I81.D_N VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXP2 ITIMERA.ISATIMER.ISA_DLY.I81.D1_N
+  ITIMERA.ISATIMER.ISA_DLY.CK_D1 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimera.Isatimer.Isa_dly.I81.MXP3 ITIMERA.ISATIMER.ISA_DLY.I81.D2
+  ITIMERA.ISATIMER.ISA_DLY.I81.D1_N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimera.Isatimer.MXN4_0 ITIMERA.ISATIMER.NBLP[0] ITIMERA.ISATIMER.RDT VSSE
+  VPW N11LL_CKT W=0.8U L=0.04U
X_MItimera.Isatimer.MXN4_1 ITIMERA.ISATIMER.NBLP[1] ITIMERA.ISATIMER.RDT VSSE
+  VPW N11LL_CKT W=0.8U L=0.04U
X_MItimera.Isatimer.MXN5_0 ITIMERA.ISATIMER.NBLP[0] ITIMERA.ISATIMER.NET315[1]
+  ITIMERA.ISATIMER.NET254[1] VPW N11LL_CKT W=1.42U L=0.04U
X_MItimera.Isatimer.MXN5_1 ITIMERA.ISATIMER.NBLP[1] ITIMERA.ISATIMER.NET315[0]
+  ITIMERA.ISATIMER.NET254[0] VPW N11LL_CKT W=1.42U L=0.04U
X_MItimera.Isatimer.MXN6_0 ITIMERA.ISATIMER.NET254[1] NWL_CLKB_A VSSE VPW
+  N11LL_CKT W=1.59U L=0.04U
X_MItimera.Isatimer.MXN6_1 ITIMERA.ISATIMER.NET254[0] NWL_CLKB_A VSSE VPW
+  N11LL_CKT W=1.59U L=0.04U
X_MItimera.Isatimer.MXP6_0 ITIMERA.ISATIMER.NBLP[0] NWL_CLKB_A
+  ITIMERA.ISATIMER.NET275 VNWP P11LL_CKT W=2.53U L=0.04U
X_MItimera.Isatimer.MXP6_1 ITIMERA.ISATIMER.NBLP[1] NWL_CLKB_A
+  ITIMERA.ISATIMER.NET275 VNWP P11LL_CKT W=2.53U L=0.04U
X_MItimera.Isatimer.MXP7_0 ITIMERA.ISATIMER.NBLP[0] ITIMERA.ISATIMER.NET315[1]
+  ITIMERA.ISATIMER.NET275 VNWP P11LL_CKT W=0.93U L=0.04U
X_MItimera.Isatimer.MXP7_1 ITIMERA.ISATIMER.NBLP[1] ITIMERA.ISATIMER.NET315[0]
+  ITIMERA.ISATIMER.NET275 VNWP P11LL_CKT W=0.93U L=0.04U
X_MItimera.Isatimer.MXP8 ITIMERA.ISATIMER.NET275 ITIMERA.ISATIMER.RDT VDDPE
+  VNWP P11LL_CKT W=6.41U L=0.04U
X_MItimerb.I10.MXNA1 ITIMERB.BNK_N BNK_B VSSE VPW N11LL_CKT W=0.36U L=0.04U
X_MItimerb.I10.MXPA1 ITIMERB.BNK_N BNK_B VDDPE VNWP P11LL_CKT W=0.72U L=0.04U
X_MItimerb.Ick_bot.I20.MXNA1 ITIMERB.ICK_BOT.BNK_RW ITIMERB.ICK_BOT.BNK_RW_N
+  VSSE VPW N11LL_CKT W=3.2U L=0.04U
X_MItimerb.Ick_bot.I20.MXPA1 ITIMERB.ICK_BOT.BNK_RW ITIMERB.ICK_BOT.BNK_RW_N
+  VDDPE VNWP P11LL_CKT W=5.68U L=0.04U
X_MItimerb.Ick_bot.I23.MXNA1 ITIMERB.ICK_BOT.BNK_RW_N ITIMERB.BNK_N
+  ITIMERB.ICK_BOT.I23.N1 VPW N11LL_CKT W=1.42U L=0.04U
X_MItimerb.Ick_bot.I23.MXNA2 ITIMERB.ICK_BOT.I23.N1 NDFTRAMBYP_B VSSE VPW
+  N11LL_CKT W=1.42U L=0.04U
X_MItimerb.Ick_bot.I23.MXPA1 ITIMERB.ICK_BOT.BNK_RW_N ITIMERB.BNK_N VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MItimerb.Ick_bot.I23.MXPA2 ITIMERB.ICK_BOT.BNK_RW_N NDFTRAMBYP_B VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MItimerb.Ick_bot.I47.MXNA1 NWL_CLKB_B CLK_B ITIMERB.ICK_BOT.I47.N1 VPW
+  N11LL_CKT W=3.56U L=0.04U
X_MItimerb.Ick_bot.I47.MXNA2 ITIMERB.ICK_BOT.I47.N1 ITIMERB.ICK_BOT.BNK_RW
+  VSSE VPW N11LL_CKT W=3.56U L=0.04U
X_MItimerb.Ick_bot.I47.MXPA1 NWL_CLKB_B CLK_B VDDPE VNWP P11LL_CKT W=2.38U
+  L=0.04U
X_MItimerb.Ick_bot.I47.MXPA2 NWL_CLKB_B ITIMERB.ICK_BOT.BNK_RW VDDPE VNWP
+  P11LL_CKT W=2.38U L=0.04U
X_MItimerb.Ick_bot.Itmrnd2.I47.MXNA1 NWL_CLKB_B CLK_B
+  ITIMERB.ICK_BOT.ITMRND2.I47.N1 VPW N11LL_CKT W=11.36U L=0.04U
X_MItimerb.Ick_bot.Itmrnd2.I47.MXNA2 ITIMERB.ICK_BOT.ITMRND2.I47.N1
+  ITIMERB.ICK_BOT.BNK_RW VSSE VPW N11LL_CKT W=14.24U L=0.04U
X_MItimerb.Ick_bot.Itmrnd2.I47.MXPA1 NWL_CLKB_B CLK_B VDDPE VNWP P11LL_CKT
+  W=6.8U L=0.04U
X_MItimerb.Ick_bot.Itmrnd2.I47.MXPA2 NWL_CLKB_B ITIMERB.ICK_BOT.BNK_RW VDDPE
+  VNWP P11LL_CKT W=6.8U L=0.04U
X_MItimerb.Icol_dec.I0_0.MXNA1 ITIMERB.ICOL_DEC.COL_SEL_N[0]
+  ITIMERB.ICOL_DEC.SEL2_N ITIMERB.ICOL_DEC.I0_0.N1 VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MItimerb.Icol_dec.I0_0.MXNA2 ITIMERB.ICOL_DEC.I0_0.N1
+  ITIMERB.ICOL_DEC.SEL1_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_0.MXPA1 ITIMERB.ICOL_DEC.COL_SEL_N[0]
+  ITIMERB.ICOL_DEC.SEL2_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_0.MXPA2 ITIMERB.ICOL_DEC.COL_SEL_N[0]
+  ITIMERB.ICOL_DEC.SEL1_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_1.MXNA1 ITIMERB.ICOL_DEC.COL_SEL_N[1]
+  ITIMERB.ICOL_DEC.SEL2_N ITIMERB.ICOL_DEC.I0_1.N1 VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MItimerb.Icol_dec.I0_1.MXNA2 ITIMERB.ICOL_DEC.I0_1.N1 CA_B[0] VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_1.MXPA1 ITIMERB.ICOL_DEC.COL_SEL_N[1]
+  ITIMERB.ICOL_DEC.SEL2_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_1.MXPA2 ITIMERB.ICOL_DEC.COL_SEL_N[1] CA_B[0] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_2.MXNA1 ITIMERB.ICOL_DEC.COL_SEL_N[2] CA_B[1]
+  ITIMERB.ICOL_DEC.I0_2.N1 VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_2.MXNA2 ITIMERB.ICOL_DEC.I0_2.N1
+  ITIMERB.ICOL_DEC.SEL1_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_2.MXPA1 ITIMERB.ICOL_DEC.COL_SEL_N[2] CA_B[1] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_2.MXPA2 ITIMERB.ICOL_DEC.COL_SEL_N[2]
+  ITIMERB.ICOL_DEC.SEL1_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_3.MXNA1 ITIMERB.ICOL_DEC.COL_SEL_N[3] CA_B[1]
+  ITIMERB.ICOL_DEC.I0_3.N1 VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_3.MXNA2 ITIMERB.ICOL_DEC.I0_3.N1 CA_B[0] VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_3.MXPA1 ITIMERB.ICOL_DEC.COL_SEL_N[3] CA_B[1] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I0_3.MXPA2 ITIMERB.ICOL_DEC.COL_SEL_N[3] CA_B[0] VDDPE
+  VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I11_0.MXNA1 ITIMERB.ICOL_DEC.SEL1_N CA_B[0] VSSE VPW
+  N11LL_CKT W=0.205U L=0.04U
X_MItimerb.Icol_dec.I11_0.MXPA1 ITIMERB.ICOL_DEC.SEL1_N CA_B[0] VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_MItimerb.Icol_dec.I11_1.MXNA1 ITIMERB.ICOL_DEC.SEL2_N CA_B[1] VSSE VPW
+  N11LL_CKT W=0.205U L=0.04U
X_MItimerb.Icol_dec.I11_1.MXPA1 ITIMERB.ICOL_DEC.SEL2_N CA_B[1] VDDPE VNWP
+  P11LL_CKT W=0.42U L=0.04U
X_MItimerb.Icol_dec.I13.MXNA1 ITIMERB.ICOL_DEC.CLK_BOT_I NWL_CLKB_B VSSE VPW
+  N11LL_CKT W=0.695U L=0.04U
X_MItimerb.Icol_dec.I13.MXPA1 ITIMERB.ICOL_DEC.CLK_BOT_I NWL_CLKB_B VDDPE VNWP
+  P11LL_CKT W=1.2U L=0.04U
X_MItimerb.Icol_dec.I15.MXNA1 ITIMERB.ICOL_DEC.NRE RE_B VSSE VPW N11LL_CKT
+  W=0.3U L=0.04U
X_MItimerb.Icol_dec.I15.MXPA1 ITIMERB.ICOL_DEC.NRE RE_B VDDPE VNWP P11LL_CKT
+  W=0.595U L=0.04U
X_MItimerb.Icol_dec.I17.MXNA1 ITIMERB.ICOL_DEC.BRE ITIMERB.ICOL_DEC.NRE VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MItimerb.Icol_dec.I17.MXPA1 ITIMERB.ICOL_DEC.BRE ITIMERB.ICOL_DEC.NRE VDDPE
+  VNWP P11LL_CKT W=0.595U L=0.04U
X_MItimerb.Icol_dec.I18.MXNA1 ITIMERB.ICOL_DEC.NWE WE_B VSSE VPW N11LL_CKT
+  W=0.3U L=0.04U
X_MItimerb.Icol_dec.I18.MXPA1 ITIMERB.ICOL_DEC.NWE WE_B VDDPE VNWP P11LL_CKT
+  W=0.595U L=0.04U
X_MItimerb.Icol_dec.I20.MXNA1 ITIMERB.ICOL_DEC.BWE ITIMERB.ICOL_DEC.NWE VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MItimerb.Icol_dec.I20.MXPA1 ITIMERB.ICOL_DEC.BWE ITIMERB.ICOL_DEC.NWE VDDPE
+  VNWP P11LL_CKT W=0.595U L=0.04U
X_MItimerb.Icol_dec.I21_0.MXNA1 ITIMERB.ICOL_DEC.COL_SEL[0]
+  ITIMERB.ICOL_DEC.COL_SEL_N[0] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I21_0.MXPA1 ITIMERB.ICOL_DEC.COL_SEL[0]
+  ITIMERB.ICOL_DEC.COL_SEL_N[0] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimerb.Icol_dec.I21_1.MXNA1 ITIMERB.ICOL_DEC.COL_SEL[1]
+  ITIMERB.ICOL_DEC.COL_SEL_N[1] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I21_1.MXPA1 ITIMERB.ICOL_DEC.COL_SEL[1]
+  ITIMERB.ICOL_DEC.COL_SEL_N[1] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimerb.Icol_dec.I21_2.MXNA1 ITIMERB.ICOL_DEC.COL_SEL[2]
+  ITIMERB.ICOL_DEC.COL_SEL_N[2] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I21_2.MXPA1 ITIMERB.ICOL_DEC.COL_SEL[2]
+  ITIMERB.ICOL_DEC.COL_SEL_N[2] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimerb.Icol_dec.I21_3.MXNA1 ITIMERB.ICOL_DEC.COL_SEL[3]
+  ITIMERB.ICOL_DEC.COL_SEL_N[3] VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Icol_dec.I21_3.MXPA1 ITIMERB.ICOL_DEC.COL_SEL[3]
+  ITIMERB.ICOL_DEC.COL_SEL_N[3] VDDPE VNWP P11LL_CKT W=0.8U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I5.MXNA1 ITIMERB.ICOL_DEC.IBOT_0.RSEL
+  ITIMERB.ICOL_DEC.IBOT_0.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I5.MXPA1 ITIMERB.ICOL_DEC.IBOT_0.RSEL
+  ITIMERB.ICOL_DEC.IBOT_0.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I6.MXNA1 NWSEL_B[0] ITIMERB.ICOL_DEC.IBOT_0.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I6.MXPA1 NWSEL_B[0] ITIMERB.ICOL_DEC.IBOT_0.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I7.MXNA1 ITIMERB.ICOL_DEC.IBOT_0.WSEL
+  ITIMERB.ICOL_DEC.IBOT_0.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I7.MXPA1 ITIMERB.ICOL_DEC.IBOT_0.WSEL
+  ITIMERB.ICOL_DEC.IBOT_0.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I8.MXNA1 NRSEL_B[0] ITIMERB.ICOL_DEC.IBOT_0.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.I8.MXPA1 NRSEL_B[0] ITIMERB.ICOL_DEC.IBOT_0.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXN0 ITIMERB.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[0] ITIMERB.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXN1 ITIMERB.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[0] ITIMERB.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXP0 ITIMERB.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERB.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXP1 ITIMERB.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXP2 ITIMERB.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXP3 ITIMERB.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERB.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXP4 ITIMERB.ICOL_DEC.IBOT_0.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[0] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_0.MXP6 ITIMERB.ICOL_DEC.IBOT_0.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[0] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I5.MXNA1 ITIMERB.ICOL_DEC.IBOT_1.RSEL
+  ITIMERB.ICOL_DEC.IBOT_1.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I5.MXPA1 ITIMERB.ICOL_DEC.IBOT_1.RSEL
+  ITIMERB.ICOL_DEC.IBOT_1.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I6.MXNA1 NWSEL_B[1] ITIMERB.ICOL_DEC.IBOT_1.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I6.MXPA1 NWSEL_B[1] ITIMERB.ICOL_DEC.IBOT_1.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I7.MXNA1 ITIMERB.ICOL_DEC.IBOT_1.WSEL
+  ITIMERB.ICOL_DEC.IBOT_1.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I7.MXPA1 ITIMERB.ICOL_DEC.IBOT_1.WSEL
+  ITIMERB.ICOL_DEC.IBOT_1.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I8.MXNA1 NRSEL_B[1] ITIMERB.ICOL_DEC.IBOT_1.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.I8.MXPA1 NRSEL_B[1] ITIMERB.ICOL_DEC.IBOT_1.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXN0 ITIMERB.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[1] ITIMERB.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXN1 ITIMERB.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[1] ITIMERB.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXP0 ITIMERB.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERB.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXP1 ITIMERB.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXP2 ITIMERB.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXP3 ITIMERB.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERB.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXP4 ITIMERB.ICOL_DEC.IBOT_1.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_1.MXP6 ITIMERB.ICOL_DEC.IBOT_1.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[1] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I5.MXNA1 ITIMERB.ICOL_DEC.IBOT_2.RSEL
+  ITIMERB.ICOL_DEC.IBOT_2.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I5.MXPA1 ITIMERB.ICOL_DEC.IBOT_2.RSEL
+  ITIMERB.ICOL_DEC.IBOT_2.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I6.MXNA1 NWSEL_B[2] ITIMERB.ICOL_DEC.IBOT_2.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I6.MXPA1 NWSEL_B[2] ITIMERB.ICOL_DEC.IBOT_2.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I7.MXNA1 ITIMERB.ICOL_DEC.IBOT_2.WSEL
+  ITIMERB.ICOL_DEC.IBOT_2.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I7.MXPA1 ITIMERB.ICOL_DEC.IBOT_2.WSEL
+  ITIMERB.ICOL_DEC.IBOT_2.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I8.MXNA1 NRSEL_B[2] ITIMERB.ICOL_DEC.IBOT_2.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.I8.MXPA1 NRSEL_B[2] ITIMERB.ICOL_DEC.IBOT_2.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXN0 ITIMERB.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[2] ITIMERB.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXN1 ITIMERB.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[2] ITIMERB.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXP0 ITIMERB.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERB.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXP1 ITIMERB.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXP2 ITIMERB.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXP3 ITIMERB.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERB.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXP4 ITIMERB.ICOL_DEC.IBOT_2.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[2] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_2.MXP6 ITIMERB.ICOL_DEC.IBOT_2.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[2] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I5.MXNA1 ITIMERB.ICOL_DEC.IBOT_3.RSEL
+  ITIMERB.ICOL_DEC.IBOT_3.RSELI_N VSSE VPW N11LL_CKT W=1U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I5.MXPA1 ITIMERB.ICOL_DEC.IBOT_3.RSEL
+  ITIMERB.ICOL_DEC.IBOT_3.RSELI_N VDDPE VNWP P11LL_CKT W=2.56U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I6.MXNA1 NWSEL_B[3] ITIMERB.ICOL_DEC.IBOT_3.WSEL
+  VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I6.MXPA1 NWSEL_B[3] ITIMERB.ICOL_DEC.IBOT_3.WSEL
+  VDDPE VNWP P11LL_CKT W=8.52U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I7.MXNA1 ITIMERB.ICOL_DEC.IBOT_3.WSEL
+  ITIMERB.ICOL_DEC.IBOT_3.WSELI_N VSSE VPW N11LL_CKT W=0.84U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I7.MXPA1 ITIMERB.ICOL_DEC.IBOT_3.WSEL
+  ITIMERB.ICOL_DEC.IBOT_3.WSELI_N VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I8.MXNA1 NRSEL_B[3] ITIMERB.ICOL_DEC.IBOT_3.RSEL
+  VSSE VPW N11LL_CKT W=6.96U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.I8.MXPA1 NRSEL_B[3] ITIMERB.ICOL_DEC.IBOT_3.RSEL
+  VDDPE VNWP P11LL_CKT W=8.4U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXN0 ITIMERB.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[3] ITIMERB.ICOL_DEC.NET82 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXN1 ITIMERB.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[3] ITIMERB.ICOL_DEC.NET86 VPW N11LL_CKT W=0.71U
+  L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXP0 ITIMERB.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERB.ICOL_DEC.BWE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXP1 ITIMERB.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.82U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXP2 ITIMERB.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERB.ICOL_DEC.CLK_BOT_I VDDPE VNWP P11LL_CKT W=0.36U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXP3 ITIMERB.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERB.ICOL_DEC.BRE VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXP4 ITIMERB.ICOL_DEC.IBOT_3.RSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[3] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.Ibot_3.MXP6 ITIMERB.ICOL_DEC.IBOT_3.WSELI_N
+  ITIMERB.ICOL_DEC.COL_SEL[3] VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MItimerb.Icol_dec.MXN3 ITIMERB.ICOL_DEC.NET81 ITIMERB.ICOL_DEC.CLK_BOT_I
+  VSSE VPW N11LL_CKT W=2.08U L=0.04U
X_MItimerb.Icol_dec.MXN4 ITIMERB.ICOL_DEC.NET86 ITIMERB.ICOL_DEC.BWE
+  ITIMERB.ICOL_DEC.NET81 VPW N11LL_CKT W=1.04U L=0.04U
X_MItimerb.Icol_dec.MXN5 ITIMERB.ICOL_DEC.NET82 ITIMERB.ICOL_DEC.BRE
+  ITIMERB.ICOL_DEC.NET81 VPW N11LL_CKT W=1.04U L=0.04U
X_MItimerb.Isatimer.I103.MXN12 ITIMERB.ISATIMER.SCLKD[0]
+  ITIMERB.ISATIMER.I103.DI1 VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I103.MXN3 ITIMERB.ISATIMER.I103.NET22 NWL_CLKB_B VSSE VPW
+  N11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I103.MXN4 ITIMERB.ISATIMER.I103.DI1
+  ITIMERB.ISATIMER.I103.NDI VSSE VPW N11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I103.MXN8 ITIMERB.ISATIMER.I103.NDI NWL_CLKB_B
+  ITIMERB.ISATIMER.I103.NET22 VPW N11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I103.MXP0 ITIMERB.ISATIMER.I103.NDI NWL_CLKB_B VDDPE VNWP
+  P11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I103.MXP1 ITIMERB.ISATIMER.I103.DI1
+  ITIMERB.ISATIMER.I103.NDI VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I103.MXP3 ITIMERB.ISATIMER.SCLKD[0]
+  ITIMERB.ISATIMER.I103.DI1 VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.I47.MXNA1 ITIMERB.ISATIMER.SB1 ITIMERB.ISATIMER.CLK_RD_N
+  ITIMERB.ISATIMER.I47.N1 VPW N11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.I47.MXNA2 ITIMERB.ISATIMER.I47.N1 ITIMERB.ISATIMER.NET97
+  VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.I47.MXPA1 ITIMERB.ISATIMER.SB1 ITIMERB.ISATIMER.CLK_RD_N
+  VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.I47.MXPA2 ITIMERB.ISATIMER.SB1 ITIMERB.ISATIMER.NET97
+  VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.I66.MXNA1 NDSA_TP_B ITIMERB.ISATIMER.SB2 VSSE VPW
+  N11LL_CKT W=5.97U L=0.04U
X_MItimerb.Isatimer.I66.MXPA1 NDSA_TP_B ITIMERB.ISATIMER.SB2 VDDPE VNWP
+  P11LL_CKT W=11.91U L=0.04U
X_MItimerb.Isatimer.I71.MXNA1 ITIMERB.ISATIMER.SB2 ITIMERB.ISATIMER.SB1 VSSE
+  VPW N11LL_CKT W=1.59U L=0.04U
X_MItimerb.Isatimer.I71.MXPA1 ITIMERB.ISATIMER.SB2 ITIMERB.ISATIMER.SB1 VDDPE
+  VNWP P11LL_CKT W=3.18U L=0.04U
X_MItimerb.Isatimer.I72.MXNA1 SA_TP_B ITIMERB.ISATIMER.SA1 VSSE VPW N11LL_CKT
+  W=7.2U L=0.04U
X_MItimerb.Isatimer.I72.MXPA1 SA_TP_B ITIMERB.ISATIMER.SA1 VDDPE VNWP
+  P11LL_CKT W=16.9U L=0.04U
X_MItimerb.Isatimer.I74.MXNA1 ITIMERB.ISATIMER.CLK_WTE_N CLK_B
+  ITIMERB.ISATIMER.I74.N1 VPW N11LL_CKT W=1.52U L=0.04U
X_MItimerb.Isatimer.I74.MXNA2 ITIMERB.ISATIMER.I74.N1 WTE_B VSSE VPW N11LL_CKT
+  W=1.52U L=0.04U
X_MItimerb.Isatimer.I74.MXPA1 ITIMERB.ISATIMER.CLK_WTE_N CLK_B VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_MItimerb.Isatimer.I74.MXPA2 ITIMERB.ISATIMER.CLK_WTE_N WTE_B VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_MItimerb.Isatimer.I75.MXNA1 ITIMERB.ISATIMER.CLK_RD_N CLK_B
+  ITIMERB.ISATIMER.I75.N2 VPW N11LL_CKT W=3U L=0.04U
X_MItimerb.Isatimer.I75.MXNA2 ITIMERB.ISATIMER.I75.N2 NDFTRAMBYP_B
+  ITIMERB.ISATIMER.I75.N1 VPW N11LL_CKT W=3U L=0.04U
X_MItimerb.Isatimer.I75.MXNA3 ITIMERB.ISATIMER.I75.N1 RE_B VSSE VPW N11LL_CKT
+  W=3U L=0.04U
X_MItimerb.Isatimer.I75.MXPA1 ITIMERB.ISATIMER.CLK_RD_N CLK_B VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_MItimerb.Isatimer.I75.MXPA2 ITIMERB.ISATIMER.CLK_RD_N NDFTRAMBYP_B VDDPE
+  VNWP P11LL_CKT W=1.99U L=0.04U
X_MItimerb.Isatimer.I75.MXPA3 ITIMERB.ISATIMER.CLK_RD_N RE_B VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_MItimerb.Isatimer.I76.MXNA1 ITIMERB.ISATIMER.SA1 ITIMERB.ISATIMER.CLK_RD_N
+  VSSE VPW N11LL_CKT W=1.59U L=0.04U
X_MItimerb.Isatimer.I76.MXPA1 ITIMERB.ISATIMER.SA1 ITIMERB.ISATIMER.CLK_RD_N
+  VDDPE VNWP P11LL_CKT W=3.18U L=0.04U
X_MItimerb.Isatimer.I77.MXNA1 ITIMERB.ISATIMER.CLK_WTE
+  ITIMERB.ISATIMER.CLK_WTE_N VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_MItimerb.Isatimer.I77.MXPA1 ITIMERB.ISATIMER.CLK_WTE
+  ITIMERB.ISATIMER.CLK_WTE_N VDDPE VNWP P11LL_CKT W=1.86U L=0.04U
X_MItimerb.Isatimer.I78.MXNA1 NWCLK_WT_B ITIMERB.ISATIMER.CLK_WTE VSSE VPW
+  N11LL_CKT W=4.25U L=0.04U
X_MItimerb.Isatimer.I78.MXPA1 NWCLK_WT_B ITIMERB.ISATIMER.CLK_WTE VDDPE VNWP
+  P11LL_CKT W=4.25U L=0.04U
X_MItimerb.Isatimer.I80.MXNA1 ITIMERB.ISATIMER.RDT ITIMERB.ISATIMER.RDTNWE
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MItimerb.Isatimer.I80.MXPA1 ITIMERB.ISATIMER.RDT ITIMERB.ISATIMER.RDTNWE
+  VDDPE VNWP P11LL_CKT W=1.13U L=0.04U
X_MItimerb.Isatimer.I818_0.MXNA1 ITIMERB.ISATIMER.NET315[1]
+  ITIMERB.ISATIMER.SCLKD[0] VSSE VPW N11LL_CKT W=0.18U L=0.04U
X_MItimerb.Isatimer.I818_0.MXNA2 ITIMERB.ISATIMER.NET315[1] RETB[0] VSSE VPW
+  N11LL_CKT W=0.18U L=0.04U
X_MItimerb.Isatimer.I818_0.MXPA1 ITIMERB.ISATIMER.NET315[1]
+  ITIMERB.ISATIMER.SCLKD[0] ITIMERB.ISATIMER.I818_0.P1 VNWP P11LL_CKT W=0.52U
+  L=0.04U
X_MItimerb.Isatimer.I818_0.MXPA2 ITIMERB.ISATIMER.I818_0.P1 RETB[0] VDDPE VNWP
+  P11LL_CKT W=0.52U L=0.04U
X_MItimerb.Isatimer.I818_1.MXNA1 ITIMERB.ISATIMER.NET315[0]
+  ITIMERB.ISATIMER.SCLKD[0] VSSE VPW N11LL_CKT W=0.18U L=0.04U
X_MItimerb.Isatimer.I818_1.MXNA2 ITIMERB.ISATIMER.NET315[0] NACT_FDBK_LB VSSE
+  VPW N11LL_CKT W=0.18U L=0.04U
X_MItimerb.Isatimer.I818_1.MXPA1 ITIMERB.ISATIMER.NET315[0]
+  ITIMERB.ISATIMER.SCLKD[0] ITIMERB.ISATIMER.I818_1.P1 VNWP P11LL_CKT W=0.52U
+  L=0.04U
X_MItimerb.Isatimer.I818_1.MXPA2 ITIMERB.ISATIMER.I818_1.P1 NACT_FDBK_LB VDDPE
+  VNWP P11LL_CKT W=0.52U L=0.04U
X_MItimerb.Isatimer.I81_0.MXNA1 PCH_BL_LB_B ITIMERB.ISATIMER.NBLP[0] VSSE VPW
+  N11LL_CKT W=3.99U L=0.04U
X_MItimerb.Isatimer.I81_0.MXPA1 PCH_BL_LB_B ITIMERB.ISATIMER.NBLP[0] VDDPE
+  VNWP P11LL_CKT W=5.25U L=0.04U
X_MItimerb.Isatimer.I81_1.MXNA1 PCH_BL_RB_B ITIMERB.ISATIMER.NBLP[1] VSSE VPW
+  N11LL_CKT W=3.99U L=0.04U
X_MItimerb.Isatimer.I81_1.MXPA1 PCH_BL_RB_B ITIMERB.ISATIMER.NBLP[1] VDDPE
+  VNWP P11LL_CKT W=5.25U L=0.04U
X_MItimerb.Isatimer.I82.MXNA1 ITIMERB.ISATIMER.NET147 WE_B VSSE VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MItimerb.Isatimer.I82.MXPA1 ITIMERB.ISATIMER.NET147 WE_B VDDPE VNWP
+  P11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I83.MXNA1 ITIMERB.ISATIMER.NET135 WE_A VSSE VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MItimerb.Isatimer.I83.MXPA1 ITIMERB.ISATIMER.NET135 WE_A VDDPE VNWP
+  P11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I84.MXNA1 ITIMERB.ISATIMER.RDTNWE ITIMERB.ISATIMER.NET147
+  ITIMERB.ISATIMER.I84.N2 VPW N11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I84.MXNA2 ITIMERB.ISATIMER.I84.N2 ITIMERB.ISATIMER.NET135
+  ITIMERB.ISATIMER.I84.N1 VPW N11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I84.MXNA3 ITIMERB.ISATIMER.I84.N1 ITIMERB.ISATIMER.NET141
+  VSSE VPW N11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I84.MXPA1 ITIMERB.ISATIMER.RDTNWE ITIMERB.ISATIMER.NET147
+  VDDPE VNWP P11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I84.MXPA2 ITIMERB.ISATIMER.RDTNWE ITIMERB.ISATIMER.NET135
+  VDDPE VNWP P11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I84.MXPA3 ITIMERB.ISATIMER.RDTNWE ITIMERB.ISATIMER.NET141
+  VDDPE VNWP P11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.I85.MXNA1 ITIMERB.ISATIMER.NET141 NRDT_B VSSE VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MItimerb.Isatimer.I85.MXPA1 ITIMERB.ISATIMER.NET141 NRDT_B VDDPE VNWP
+  P11LL_CKT W=0.29U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I54.MXNA1 ITIMERB.ISATIMER.ISA_DLY.A0
+  ITIMERB.ISATIMER.ISA_DLY.CK_D2 ITIMERB.ISATIMER.ISA_DLY.I54.N1 VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I54.MXNA2 ITIMERB.ISATIMER.ISA_DLY.I54.N1
+  ITIMERB.ISATIMER.ISA_DLY.CK_D2 VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I54.MXPA1 ITIMERB.ISATIMER.ISA_DLY.A0
+  ITIMERB.ISATIMER.ISA_DLY.CK_D2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I54.MXPA2 ITIMERB.ISATIMER.ISA_DLY.A0
+  ITIMERB.ISATIMER.ISA_DLY.CK_D2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I55.MXNA1 ITIMERB.ISATIMER.NET97
+  ITIMERB.ISATIMER.ISA_DLY.A0 ITIMERB.ISATIMER.ISA_DLY.I55.N1 VPW N11LL_CKT
+  W=0.795U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I55.MXNA2 ITIMERB.ISATIMER.ISA_DLY.I55.N1
+  ITIMERB.ISATIMER.ISA_DLY.A0 VSSE VPW N11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I55.MXPA1 ITIMERB.ISATIMER.NET97
+  ITIMERB.ISATIMER.ISA_DLY.A0 VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I55.MXPA2 ITIMERB.ISATIMER.NET97
+  ITIMERB.ISATIMER.ISA_DLY.A0 VDDPE VNWP P11LL_CKT W=0.795U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN0 ITIMERB.ISATIMER.ISA_DLY.I80.NET0137
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN11 ITIMERB.ISATIMER.ISA_DLY.I80.NET0141
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN12 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY_N
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY ITIMERB.ISATIMER.ISA_DLY.I80.NET0137 VPW
+  N11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN13 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2_N
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2 ITIMERB.ISATIMER.ISA_DLY.I80.NET0141
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN2 ITIMERB.ISATIMER.ISA_DLY.I80.NET104
+  ITIMERB.ISATIMER.CLK_RD_N VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN3 ITIMERB.ISATIMER.ISA_DLY.I80.D_N
+  ITIMERB.ISATIMER.CLK_RD_N ITIMERB.ISATIMER.ISA_DLY.I80.NET104 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN4 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN5 VSSE ITIMERB.ISATIMER.ISA_DLY.I80.D_N
+  VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN7 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXN8 ITIMERB.ISATIMER.ISA_DLY.CK_D1
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP0 ITIMERB.ISATIMER.ISA_DLY.I80.D_N
+  ITIMERB.ISATIMER.CLK_RD_N VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP1 ITIMERB.ISATIMER.ISA_DLY.I80.NET074
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP2 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY_N
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP3 ITIMERB.ISATIMER.ISA_DLY.I80.NET066
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY_N VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP5 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2_N
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP6 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_N ITIMERB.ISATIMER.ISA_DLY.I80.NET074 VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP7 ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY_N ITIMERB.ISATIMER.ISA_DLY.I80.NET066
+  VNWP P11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I80.MXP8 ITIMERB.ISATIMER.ISA_DLY.CK_D1
+  ITIMERB.ISATIMER.ISA_DLY.I80.D_DLY2_N VDDPE VNWP P11LL_CKT W=0.345U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN0 ITIMERB.ISATIMER.ISA_DLY.I81.NET066
+  ITIMERB.ISATIMER.ISA_DLY.CK_D1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN1 ITIMERB.ISATIMER.ISA_DLY.I81.D1_N
+  ITIMERB.ISATIMER.ISA_DLY.CK_D1 ITIMERB.ISATIMER.ISA_DLY.I81.NET066 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN2 ITIMERB.ISATIMER.ISA_DLY.I81.NET46
+  ITIMERB.ISATIMER.ISA_DLY.CK_D1 VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN3 ITIMERB.ISATIMER.ISA_DLY.I81.D_N
+  ITIMERB.ISATIMER.ISA_DLY.CK_D1 ITIMERB.ISATIMER.ISA_DLY.I81.NET46 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN4 ITIMERB.ISATIMER.ISA_DLY.CK_D2
+  ITIMERB.ISATIMER.ISA_DLY.I81.D_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN5 VSSE ITIMERB.ISATIMER.ISA_DLY.I81.D_N
+  VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN6 ITIMERB.ISATIMER.ISA_DLY.I81.D2
+  ITIMERB.ISATIMER.ISA_DLY.I81.D1_N VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXN7 VSSE ITIMERB.ISATIMER.ISA_DLY.I81.D1_N
+  VSSE VPW N11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXP0 ITIMERB.ISATIMER.ISA_DLY.I81.D_N
+  ITIMERB.ISATIMER.ISA_DLY.CK_D1 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXP1 ITIMERB.ISATIMER.ISA_DLY.CK_D2
+  ITIMERB.ISATIMER.ISA_DLY.I81.D_N VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXP2 ITIMERB.ISATIMER.ISA_DLY.I81.D1_N
+  ITIMERB.ISATIMER.ISA_DLY.CK_D1 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MItimerb.Isatimer.Isa_dly.I81.MXP3 ITIMERB.ISATIMER.ISA_DLY.I81.D2
+  ITIMERB.ISATIMER.ISA_DLY.I81.D1_N VDDPE VNWP P11LL_CKT W=0.28U L=0.04U
X_MItimerb.Isatimer.MXN4_0 ITIMERB.ISATIMER.NBLP[0] ITIMERB.ISATIMER.RDT VSSE
+  VPW N11LL_CKT W=0.8U L=0.04U
X_MItimerb.Isatimer.MXN4_1 ITIMERB.ISATIMER.NBLP[1] ITIMERB.ISATIMER.RDT VSSE
+  VPW N11LL_CKT W=0.8U L=0.04U
X_MItimerb.Isatimer.MXN5_0 ITIMERB.ISATIMER.NBLP[0] ITIMERB.ISATIMER.NET315[1]
+  ITIMERB.ISATIMER.NET254[1] VPW N11LL_CKT W=1.42U L=0.04U
X_MItimerb.Isatimer.MXN5_1 ITIMERB.ISATIMER.NBLP[1] ITIMERB.ISATIMER.NET315[0]
+  ITIMERB.ISATIMER.NET254[0] VPW N11LL_CKT W=1.42U L=0.04U
X_MItimerb.Isatimer.MXN6_0 ITIMERB.ISATIMER.NET254[1] NWL_CLKB_B VSSE VPW
+  N11LL_CKT W=1.59U L=0.04U
X_MItimerb.Isatimer.MXN6_1 ITIMERB.ISATIMER.NET254[0] NWL_CLKB_B VSSE VPW
+  N11LL_CKT W=1.59U L=0.04U
X_MItimerb.Isatimer.MXP6_0 ITIMERB.ISATIMER.NBLP[0] NWL_CLKB_B
+  ITIMERB.ISATIMER.NET275 VNWP P11LL_CKT W=2.53U L=0.04U
X_MItimerb.Isatimer.MXP6_1 ITIMERB.ISATIMER.NBLP[1] NWL_CLKB_B
+  ITIMERB.ISATIMER.NET275 VNWP P11LL_CKT W=2.53U L=0.04U
X_MItimerb.Isatimer.MXP7_0 ITIMERB.ISATIMER.NBLP[0] ITIMERB.ISATIMER.NET315[1]
+  ITIMERB.ISATIMER.NET275 VNWP P11LL_CKT W=0.93U L=0.04U
X_MItimerb.Isatimer.MXP7_1 ITIMERB.ISATIMER.NBLP[1] ITIMERB.ISATIMER.NET315[0]
+  ITIMERB.ISATIMER.NET275 VNWP P11LL_CKT W=0.93U L=0.04U
X_MItimerb.Isatimer.MXP8 ITIMERB.ISATIMER.NET275 ITIMERB.ISATIMER.RDT VDDPE
+  VNWP P11LL_CKT W=6.41U L=0.04U
X_MItmrlogicgen.Itmrlogicgen.MXN0 NET397 ITMRLOGICGEN.ITMRLOGICGEN.NODEB VSSE
+  VPW N11LL_CKT W=1.42U L=0.04U
X_MItmrlogicgen.Itmrlogicgen.MXN1 ITMRLOGICGEN.ITMRLOGICGEN.NODEA
+  ITMRLOGICGEN.ITMRLOGICGEN.NODEA VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_MItmrlogicgen.Itmrlogicgen.MXN2 ITMRLOGICGEN.ITMRLOGICGEN.NODEA
+  ITMRLOGICGEN.ITMRLOGICGEN.NODEB VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_MItmrlogicgen.Itmrlogicgen.MXP1 ITMRLOGICGEN.ITMRLOGICGEN.NODEB
+  ITMRLOGICGEN.ITMRLOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MItmrlogicgen.Itmrlogicgen.MXP4 LOGIC1 ITMRLOGICGEN.ITMRLOGICGEN.NODEA VDDPE
+  VNWP P11LL_CKT W=2.84U L=0.04U
X_MXN0 TMR_TIELO LOGIC1 VSSE VPW N11LL_CKT W=2.98U L=0.04U
X_MXN16 VSSE SA_TIELO VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_MXN2 SA_TIELO LOGIC1 VSSE VPW N11LL_CKT W=11.36U L=0.04U
X_MXN5 VSSE SA_TIELO VSSE VPW N11LL_CKT W=0.28U L=0.08U
X_MXN6 VSSE SA_TIELO VSSE VPW N11LL_CKT W=0.28U L=0.08U
X_MXN7 VSSE SA_TIELO VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_MXP0_0 NDFTRAMBYP_B IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_1 RE_B IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_10 NXPDEC2_B[4] IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_11 BNK_B IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_2 WTE_B IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_3 WRB_MA IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_4 NRDT_B IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_5 WE_B IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_6 NXPDEC3_B[0] IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_7 NXPDEC3_B[1] IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_8 NXPDEC3_B[2] IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP0_9 NXPDEC3_B[3] IACTCLMP_B VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP1_0 VDDCA NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP1_1 VDDCA NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP1_2 VDDCA NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP2_0 VDDCB NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP2_1 VDDCB NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP2_2 VDDCB NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP3 VDDCA NHDR_WL_A VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP4 VDDCB NHDR_WL_B VDDCE VNWC P11LL_CKT W=6.25U L=0.04U
X_MXP6_0 NDFTRAMBYP_A IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_1 RE_A IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_10 NXPDEC2_A[4] IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_11 BNK_A IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_2 WTE_A IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_3 WRA_MA IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_4 NRDT_A IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_5 WE_A IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_6 NXPDEC3_A[0] IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_7 NXPDEC3_A[1] IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_8 NXPDEC3_A[2] IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP6_9 NXPDEC3_A[3] IACTCLMP_A VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
.ENDS SRAMdpw64d256TIMER
****
.SUBCKT SRAMdpw64d256COLMXDN32320 ACTCLMP_A ACTCLMP_B BLB_A[0]_0 BLB_A[0]_1
+  BLB_A[0]_2 BLB_A[0]_3 BLB_A[0]_4 BLB_A[0]_5 BLB_A[0]_6 BLB_A[0]_7
+  BLB_A[0]_8 BLB_A[0]_9 BLB_A[0]_10 BLB_A[0]_11 BLB_A[0]_12 BLB_A[0]_13
+  BLB_A[0]_14 BLB_A[0]_15 BLB_A[0]_16 BLB_A[0]_17 BLB_A[0]_18 BLB_A[0]_19
+  BLB_A[0]_20 BLB_A[0]_21 BLB_A[0]_22 BLB_A[0]_23 BLB_A[0]_24 BLB_A[0]_25
+  BLB_A[0]_26 BLB_A[0]_27 BLB_A[0]_28 BLB_A[0]_29 BLB_A[0]_30 BLB_A[0]_31
+  BLB_A[0]_32 BLB_A[0]_33 BLB_A[0]_34 BLB_A[0]_35 BLB_A[0]_36 BLB_A[0]_37
+  BLB_A[0]_38 BLB_A[0]_39 BLB_A[0]_40 BLB_A[0]_41 BLB_A[0]_42 BLB_A[0]_43
+  BLB_A[0]_44 BLB_A[0]_45 BLB_A[0]_46 BLB_A[0]_47 BLB_A[0]_48 BLB_A[0]_49
+  BLB_A[0]_50 BLB_A[0]_51 BLB_A[0]_52 BLB_A[0]_53 BLB_A[0]_54 BLB_A[0]_55
+  BLB_A[0]_56 BLB_A[0]_57 BLB_A[0]_58 BLB_A[0]_59 BLB_A[0]_60 BLB_A[0]_61
+  BLB_A[0]_62 BLB_A[0]_63 BLB_A[1]_0 BLB_A[1]_1 BLB_A[1]_2 BLB_A[1]_3
+  BLB_A[1]_4 BLB_A[1]_5 BLB_A[1]_6 BLB_A[1]_7 BLB_A[1]_8 BLB_A[1]_9
+  BLB_A[1]_10 BLB_A[1]_11 BLB_A[1]_12 BLB_A[1]_13 BLB_A[1]_14 BLB_A[1]_15
+  BLB_A[1]_16 BLB_A[1]_17 BLB_A[1]_18 BLB_A[1]_19 BLB_A[1]_20 BLB_A[1]_21
+  BLB_A[1]_22 BLB_A[1]_23 BLB_A[1]_24 BLB_A[1]_25 BLB_A[1]_26 BLB_A[1]_27
+  BLB_A[1]_28 BLB_A[1]_29 BLB_A[1]_30 BLB_A[1]_31 BLB_A[1]_32 BLB_A[1]_33
+  BLB_A[1]_34 BLB_A[1]_35 BLB_A[1]_36 BLB_A[1]_37 BLB_A[1]_38 BLB_A[1]_39
+  BLB_A[1]_40 BLB_A[1]_41 BLB_A[1]_42 BLB_A[1]_43 BLB_A[1]_44 BLB_A[1]_45
+  BLB_A[1]_46 BLB_A[1]_47 BLB_A[1]_48 BLB_A[1]_49 BLB_A[1]_50 BLB_A[1]_51
+  BLB_A[1]_52 BLB_A[1]_53 BLB_A[1]_54 BLB_A[1]_55 BLB_A[1]_56 BLB_A[1]_57
+  BLB_A[1]_58 BLB_A[1]_59 BLB_A[1]_60 BLB_A[1]_61 BLB_A[1]_62 BLB_A[1]_63
+  BLB_A[2]_0 BLB_A[2]_1 BLB_A[2]_2 BLB_A[2]_3 BLB_A[2]_4 BLB_A[2]_5
+  BLB_A[2]_6 BLB_A[2]_7 BLB_A[2]_8 BLB_A[2]_9 BLB_A[2]_10 BLB_A[2]_11
+  BLB_A[2]_12 BLB_A[2]_13 BLB_A[2]_14 BLB_A[2]_15 BLB_A[2]_16 BLB_A[2]_17
+  BLB_A[2]_18 BLB_A[2]_19 BLB_A[2]_20 BLB_A[2]_21 BLB_A[2]_22 BLB_A[2]_23
+  BLB_A[2]_24 BLB_A[2]_25 BLB_A[2]_26 BLB_A[2]_27 BLB_A[2]_28 BLB_A[2]_29
+  BLB_A[2]_30 BLB_A[2]_31 BLB_A[2]_32 BLB_A[2]_33 BLB_A[2]_34 BLB_A[2]_35
+  BLB_A[2]_36 BLB_A[2]_37 BLB_A[2]_38 BLB_A[2]_39 BLB_A[2]_40 BLB_A[2]_41
+  BLB_A[2]_42 BLB_A[2]_43 BLB_A[2]_44 BLB_A[2]_45 BLB_A[2]_46 BLB_A[2]_47
+  BLB_A[2]_48 BLB_A[2]_49 BLB_A[2]_50 BLB_A[2]_51 BLB_A[2]_52 BLB_A[2]_53
+  BLB_A[2]_54 BLB_A[2]_55 BLB_A[2]_56 BLB_A[2]_57 BLB_A[2]_58 BLB_A[2]_59
+  BLB_A[2]_60 BLB_A[2]_61 BLB_A[2]_62 BLB_A[2]_63 BLB_A[3]_0 BLB_A[3]_1
+  BLB_A[3]_2 BLB_A[3]_3 BLB_A[3]_4 BLB_A[3]_5 BLB_A[3]_6 BLB_A[3]_7
+  BLB_A[3]_8 BLB_A[3]_9 BLB_A[3]_10 BLB_A[3]_11 BLB_A[3]_12 BLB_A[3]_13
+  BLB_A[3]_14 BLB_A[3]_15 BLB_A[3]_16 BLB_A[3]_17 BLB_A[3]_18 BLB_A[3]_19
+  BLB_A[3]_20 BLB_A[3]_21 BLB_A[3]_22 BLB_A[3]_23 BLB_A[3]_24 BLB_A[3]_25
+  BLB_A[3]_26 BLB_A[3]_27 BLB_A[3]_28 BLB_A[3]_29 BLB_A[3]_30 BLB_A[3]_31
+  BLB_A[3]_32 BLB_A[3]_33 BLB_A[3]_34 BLB_A[3]_35 BLB_A[3]_36 BLB_A[3]_37
+  BLB_A[3]_38 BLB_A[3]_39 BLB_A[3]_40 BLB_A[3]_41 BLB_A[3]_42 BLB_A[3]_43
+  BLB_A[3]_44 BLB_A[3]_45 BLB_A[3]_46 BLB_A[3]_47 BLB_A[3]_48 BLB_A[3]_49
+  BLB_A[3]_50 BLB_A[3]_51 BLB_A[3]_52 BLB_A[3]_53 BLB_A[3]_54 BLB_A[3]_55
+  BLB_A[3]_56 BLB_A[3]_57 BLB_A[3]_58 BLB_A[3]_59 BLB_A[3]_60 BLB_A[3]_61
+  BLB_A[3]_62 BLB_A[3]_63 BLB_B[0]_0 BLB_B[0]_1 BLB_B[0]_2 BLB_B[0]_3
+  BLB_B[0]_4 BLB_B[0]_5 BLB_B[0]_6 BLB_B[0]_7 BLB_B[0]_8 BLB_B[0]_9
+  BLB_B[0]_10 BLB_B[0]_11 BLB_B[0]_12 BLB_B[0]_13 BLB_B[0]_14 BLB_B[0]_15
+  BLB_B[0]_16 BLB_B[0]_17 BLB_B[0]_18 BLB_B[0]_19 BLB_B[0]_20 BLB_B[0]_21
+  BLB_B[0]_22 BLB_B[0]_23 BLB_B[0]_24 BLB_B[0]_25 BLB_B[0]_26 BLB_B[0]_27
+  BLB_B[0]_28 BLB_B[0]_29 BLB_B[0]_30 BLB_B[0]_31 BLB_B[0]_32 BLB_B[0]_33
+  BLB_B[0]_34 BLB_B[0]_35 BLB_B[0]_36 BLB_B[0]_37 BLB_B[0]_38 BLB_B[0]_39
+  BLB_B[0]_40 BLB_B[0]_41 BLB_B[0]_42 BLB_B[0]_43 BLB_B[0]_44 BLB_B[0]_45
+  BLB_B[0]_46 BLB_B[0]_47 BLB_B[0]_48 BLB_B[0]_49 BLB_B[0]_50 BLB_B[0]_51
+  BLB_B[0]_52 BLB_B[0]_53 BLB_B[0]_54 BLB_B[0]_55 BLB_B[0]_56 BLB_B[0]_57
+  BLB_B[0]_58 BLB_B[0]_59 BLB_B[0]_60 BLB_B[0]_61 BLB_B[0]_62 BLB_B[0]_63
+  BLB_B[1]_0 BLB_B[1]_1 BLB_B[1]_2 BLB_B[1]_3 BLB_B[1]_4 BLB_B[1]_5
+  BLB_B[1]_6 BLB_B[1]_7 BLB_B[1]_8 BLB_B[1]_9 BLB_B[1]_10 BLB_B[1]_11
+  BLB_B[1]_12 BLB_B[1]_13 BLB_B[1]_14 BLB_B[1]_15 BLB_B[1]_16 BLB_B[1]_17
+  BLB_B[1]_18 BLB_B[1]_19 BLB_B[1]_20 BLB_B[1]_21 BLB_B[1]_22 BLB_B[1]_23
+  BLB_B[1]_24 BLB_B[1]_25 BLB_B[1]_26 BLB_B[1]_27 BLB_B[1]_28 BLB_B[1]_29
+  BLB_B[1]_30 BLB_B[1]_31 BLB_B[1]_32 BLB_B[1]_33 BLB_B[1]_34 BLB_B[1]_35
+  BLB_B[1]_36 BLB_B[1]_37 BLB_B[1]_38 BLB_B[1]_39 BLB_B[1]_40 BLB_B[1]_41
+  BLB_B[1]_42 BLB_B[1]_43 BLB_B[1]_44 BLB_B[1]_45 BLB_B[1]_46 BLB_B[1]_47
+  BLB_B[1]_48 BLB_B[1]_49 BLB_B[1]_50 BLB_B[1]_51 BLB_B[1]_52 BLB_B[1]_53
+  BLB_B[1]_54 BLB_B[1]_55 BLB_B[1]_56 BLB_B[1]_57 BLB_B[1]_58 BLB_B[1]_59
+  BLB_B[1]_60 BLB_B[1]_61 BLB_B[1]_62 BLB_B[1]_63 BLB_B[2]_0 BLB_B[2]_1
+  BLB_B[2]_2 BLB_B[2]_3 BLB_B[2]_4 BLB_B[2]_5 BLB_B[2]_6 BLB_B[2]_7
+  BLB_B[2]_8 BLB_B[2]_9 BLB_B[2]_10 BLB_B[2]_11 BLB_B[2]_12 BLB_B[2]_13
+  BLB_B[2]_14 BLB_B[2]_15 BLB_B[2]_16 BLB_B[2]_17 BLB_B[2]_18 BLB_B[2]_19
+  BLB_B[2]_20 BLB_B[2]_21 BLB_B[2]_22 BLB_B[2]_23 BLB_B[2]_24 BLB_B[2]_25
+  BLB_B[2]_26 BLB_B[2]_27 BLB_B[2]_28 BLB_B[2]_29 BLB_B[2]_30 BLB_B[2]_31
+  BLB_B[2]_32 BLB_B[2]_33 BLB_B[2]_34 BLB_B[2]_35 BLB_B[2]_36 BLB_B[2]_37
+  BLB_B[2]_38 BLB_B[2]_39 BLB_B[2]_40 BLB_B[2]_41 BLB_B[2]_42 BLB_B[2]_43
+  BLB_B[2]_44 BLB_B[2]_45 BLB_B[2]_46 BLB_B[2]_47 BLB_B[2]_48 BLB_B[2]_49
+  BLB_B[2]_50 BLB_B[2]_51 BLB_B[2]_52 BLB_B[2]_53 BLB_B[2]_54 BLB_B[2]_55
+  BLB_B[2]_56 BLB_B[2]_57 BLB_B[2]_58 BLB_B[2]_59 BLB_B[2]_60 BLB_B[2]_61
+  BLB_B[2]_62 BLB_B[2]_63 BLB_B[3]_0 BLB_B[3]_1 BLB_B[3]_2 BLB_B[3]_3
+  BLB_B[3]_4 BLB_B[3]_5 BLB_B[3]_6 BLB_B[3]_7 BLB_B[3]_8 BLB_B[3]_9
+  BLB_B[3]_10 BLB_B[3]_11 BLB_B[3]_12 BLB_B[3]_13 BLB_B[3]_14 BLB_B[3]_15
+  BLB_B[3]_16 BLB_B[3]_17 BLB_B[3]_18 BLB_B[3]_19 BLB_B[3]_20 BLB_B[3]_21
+  BLB_B[3]_22 BLB_B[3]_23 BLB_B[3]_24 BLB_B[3]_25 BLB_B[3]_26 BLB_B[3]_27
+  BLB_B[3]_28 BLB_B[3]_29 BLB_B[3]_30 BLB_B[3]_31 BLB_B[3]_32 BLB_B[3]_33
+  BLB_B[3]_34 BLB_B[3]_35 BLB_B[3]_36 BLB_B[3]_37 BLB_B[3]_38 BLB_B[3]_39
+  BLB_B[3]_40 BLB_B[3]_41 BLB_B[3]_42 BLB_B[3]_43 BLB_B[3]_44 BLB_B[3]_45
+  BLB_B[3]_46 BLB_B[3]_47 BLB_B[3]_48 BLB_B[3]_49 BLB_B[3]_50 BLB_B[3]_51
+  BLB_B[3]_52 BLB_B[3]_53 BLB_B[3]_54 BLB_B[3]_55 BLB_B[3]_56 BLB_B[3]_57
+  BLB_B[3]_58 BLB_B[3]_59 BLB_B[3]_60 BLB_B[3]_61 BLB_B[3]_62 BLB_B[3]_63
+  BNK_A BNK_B CA_A[0] CA_A[1] CA_B[0] CA_B[1] CLK_A CLK_B DATAIN_A_0
+  DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6
+  DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12
+  DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18
+  DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24
+  DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30
+  DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36
+  DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42
+  DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48
+  DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54
+  DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60
+  DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2
+  DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8
+  DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14
+  DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20
+  DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26
+  DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32
+  DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38
+  DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44
+  DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50
+  DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56
+  DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62
+  DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5
+  GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13
+  GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21
+  GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29
+  GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37
+  GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45
+  GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53
+  GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61
+  GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6
+  GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14
+  GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22
+  GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30
+  GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38
+  GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46
+  GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54
+  GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62
+  GDL_B_63 IACTCLMP_A IACTCLMP_B LOG0_DBL_A LOG0_DBL_B NACT NBLB_A[0]_0
+  NBLB_A[0]_1 NBLB_A[0]_2 NBLB_A[0]_3 NBLB_A[0]_4 NBLB_A[0]_5 NBLB_A[0]_6
+  NBLB_A[0]_7 NBLB_A[0]_8 NBLB_A[0]_9 NBLB_A[0]_10 NBLB_A[0]_11 NBLB_A[0]_12
+  NBLB_A[0]_13 NBLB_A[0]_14 NBLB_A[0]_15 NBLB_A[0]_16 NBLB_A[0]_17
+  NBLB_A[0]_18 NBLB_A[0]_19 NBLB_A[0]_20 NBLB_A[0]_21 NBLB_A[0]_22
+  NBLB_A[0]_23 NBLB_A[0]_24 NBLB_A[0]_25 NBLB_A[0]_26 NBLB_A[0]_27
+  NBLB_A[0]_28 NBLB_A[0]_29 NBLB_A[0]_30 NBLB_A[0]_31 NBLB_A[0]_32
+  NBLB_A[0]_33 NBLB_A[0]_34 NBLB_A[0]_35 NBLB_A[0]_36 NBLB_A[0]_37
+  NBLB_A[0]_38 NBLB_A[0]_39 NBLB_A[0]_40 NBLB_A[0]_41 NBLB_A[0]_42
+  NBLB_A[0]_43 NBLB_A[0]_44 NBLB_A[0]_45 NBLB_A[0]_46 NBLB_A[0]_47
+  NBLB_A[0]_48 NBLB_A[0]_49 NBLB_A[0]_50 NBLB_A[0]_51 NBLB_A[0]_52
+  NBLB_A[0]_53 NBLB_A[0]_54 NBLB_A[0]_55 NBLB_A[0]_56 NBLB_A[0]_57
+  NBLB_A[0]_58 NBLB_A[0]_59 NBLB_A[0]_60 NBLB_A[0]_61 NBLB_A[0]_62
+  NBLB_A[0]_63 NBLB_A[1]_0 NBLB_A[1]_1 NBLB_A[1]_2 NBLB_A[1]_3 NBLB_A[1]_4
+  NBLB_A[1]_5 NBLB_A[1]_6 NBLB_A[1]_7 NBLB_A[1]_8 NBLB_A[1]_9 NBLB_A[1]_10
+  NBLB_A[1]_11 NBLB_A[1]_12 NBLB_A[1]_13 NBLB_A[1]_14 NBLB_A[1]_15
+  NBLB_A[1]_16 NBLB_A[1]_17 NBLB_A[1]_18 NBLB_A[1]_19 NBLB_A[1]_20
+  NBLB_A[1]_21 NBLB_A[1]_22 NBLB_A[1]_23 NBLB_A[1]_24 NBLB_A[1]_25
+  NBLB_A[1]_26 NBLB_A[1]_27 NBLB_A[1]_28 NBLB_A[1]_29 NBLB_A[1]_30
+  NBLB_A[1]_31 NBLB_A[1]_32 NBLB_A[1]_33 NBLB_A[1]_34 NBLB_A[1]_35
+  NBLB_A[1]_36 NBLB_A[1]_37 NBLB_A[1]_38 NBLB_A[1]_39 NBLB_A[1]_40
+  NBLB_A[1]_41 NBLB_A[1]_42 NBLB_A[1]_43 NBLB_A[1]_44 NBLB_A[1]_45
+  NBLB_A[1]_46 NBLB_A[1]_47 NBLB_A[1]_48 NBLB_A[1]_49 NBLB_A[1]_50
+  NBLB_A[1]_51 NBLB_A[1]_52 NBLB_A[1]_53 NBLB_A[1]_54 NBLB_A[1]_55
+  NBLB_A[1]_56 NBLB_A[1]_57 NBLB_A[1]_58 NBLB_A[1]_59 NBLB_A[1]_60
+  NBLB_A[1]_61 NBLB_A[1]_62 NBLB_A[1]_63 NBLB_A[2]_0 NBLB_A[2]_1 NBLB_A[2]_2
+  NBLB_A[2]_3 NBLB_A[2]_4 NBLB_A[2]_5 NBLB_A[2]_6 NBLB_A[2]_7 NBLB_A[2]_8
+  NBLB_A[2]_9 NBLB_A[2]_10 NBLB_A[2]_11 NBLB_A[2]_12 NBLB_A[2]_13
+  NBLB_A[2]_14 NBLB_A[2]_15 NBLB_A[2]_16 NBLB_A[2]_17 NBLB_A[2]_18
+  NBLB_A[2]_19 NBLB_A[2]_20 NBLB_A[2]_21 NBLB_A[2]_22 NBLB_A[2]_23
+  NBLB_A[2]_24 NBLB_A[2]_25 NBLB_A[2]_26 NBLB_A[2]_27 NBLB_A[2]_28
+  NBLB_A[2]_29 NBLB_A[2]_30 NBLB_A[2]_31 NBLB_A[2]_32 NBLB_A[2]_33
+  NBLB_A[2]_34 NBLB_A[2]_35 NBLB_A[2]_36 NBLB_A[2]_37 NBLB_A[2]_38
+  NBLB_A[2]_39 NBLB_A[2]_40 NBLB_A[2]_41 NBLB_A[2]_42 NBLB_A[2]_43
+  NBLB_A[2]_44 NBLB_A[2]_45 NBLB_A[2]_46 NBLB_A[2]_47 NBLB_A[2]_48
+  NBLB_A[2]_49 NBLB_A[2]_50 NBLB_A[2]_51 NBLB_A[2]_52 NBLB_A[2]_53
+  NBLB_A[2]_54 NBLB_A[2]_55 NBLB_A[2]_56 NBLB_A[2]_57 NBLB_A[2]_58
+  NBLB_A[2]_59 NBLB_A[2]_60 NBLB_A[2]_61 NBLB_A[2]_62 NBLB_A[2]_63
+  NBLB_A[3]_0 NBLB_A[3]_1 NBLB_A[3]_2 NBLB_A[3]_3 NBLB_A[3]_4 NBLB_A[3]_5
+  NBLB_A[3]_6 NBLB_A[3]_7 NBLB_A[3]_8 NBLB_A[3]_9 NBLB_A[3]_10 NBLB_A[3]_11
+  NBLB_A[3]_12 NBLB_A[3]_13 NBLB_A[3]_14 NBLB_A[3]_15 NBLB_A[3]_16
+  NBLB_A[3]_17 NBLB_A[3]_18 NBLB_A[3]_19 NBLB_A[3]_20 NBLB_A[3]_21
+  NBLB_A[3]_22 NBLB_A[3]_23 NBLB_A[3]_24 NBLB_A[3]_25 NBLB_A[3]_26
+  NBLB_A[3]_27 NBLB_A[3]_28 NBLB_A[3]_29 NBLB_A[3]_30 NBLB_A[3]_31
+  NBLB_A[3]_32 NBLB_A[3]_33 NBLB_A[3]_34 NBLB_A[3]_35 NBLB_A[3]_36
+  NBLB_A[3]_37 NBLB_A[3]_38 NBLB_A[3]_39 NBLB_A[3]_40 NBLB_A[3]_41
+  NBLB_A[3]_42 NBLB_A[3]_43 NBLB_A[3]_44 NBLB_A[3]_45 NBLB_A[3]_46
+  NBLB_A[3]_47 NBLB_A[3]_48 NBLB_A[3]_49 NBLB_A[3]_50 NBLB_A[3]_51
+  NBLB_A[3]_52 NBLB_A[3]_53 NBLB_A[3]_54 NBLB_A[3]_55 NBLB_A[3]_56
+  NBLB_A[3]_57 NBLB_A[3]_58 NBLB_A[3]_59 NBLB_A[3]_60 NBLB_A[3]_61
+  NBLB_A[3]_62 NBLB_A[3]_63 NBLB_B[0]_0 NBLB_B[0]_1 NBLB_B[0]_2 NBLB_B[0]_3
+  NBLB_B[0]_4 NBLB_B[0]_5 NBLB_B[0]_6 NBLB_B[0]_7 NBLB_B[0]_8 NBLB_B[0]_9
+  NBLB_B[0]_10 NBLB_B[0]_11 NBLB_B[0]_12 NBLB_B[0]_13 NBLB_B[0]_14
+  NBLB_B[0]_15 NBLB_B[0]_16 NBLB_B[0]_17 NBLB_B[0]_18 NBLB_B[0]_19
+  NBLB_B[0]_20 NBLB_B[0]_21 NBLB_B[0]_22 NBLB_B[0]_23 NBLB_B[0]_24
+  NBLB_B[0]_25 NBLB_B[0]_26 NBLB_B[0]_27 NBLB_B[0]_28 NBLB_B[0]_29
+  NBLB_B[0]_30 NBLB_B[0]_31 NBLB_B[0]_32 NBLB_B[0]_33 NBLB_B[0]_34
+  NBLB_B[0]_35 NBLB_B[0]_36 NBLB_B[0]_37 NBLB_B[0]_38 NBLB_B[0]_39
+  NBLB_B[0]_40 NBLB_B[0]_41 NBLB_B[0]_42 NBLB_B[0]_43 NBLB_B[0]_44
+  NBLB_B[0]_45 NBLB_B[0]_46 NBLB_B[0]_47 NBLB_B[0]_48 NBLB_B[0]_49
+  NBLB_B[0]_50 NBLB_B[0]_51 NBLB_B[0]_52 NBLB_B[0]_53 NBLB_B[0]_54
+  NBLB_B[0]_55 NBLB_B[0]_56 NBLB_B[0]_57 NBLB_B[0]_58 NBLB_B[0]_59
+  NBLB_B[0]_60 NBLB_B[0]_61 NBLB_B[0]_62 NBLB_B[0]_63 NBLB_B[1]_0 NBLB_B[1]_1
+  NBLB_B[1]_2 NBLB_B[1]_3 NBLB_B[1]_4 NBLB_B[1]_5 NBLB_B[1]_6 NBLB_B[1]_7
+  NBLB_B[1]_8 NBLB_B[1]_9 NBLB_B[1]_10 NBLB_B[1]_11 NBLB_B[1]_12 NBLB_B[1]_13
+  NBLB_B[1]_14 NBLB_B[1]_15 NBLB_B[1]_16 NBLB_B[1]_17 NBLB_B[1]_18
+  NBLB_B[1]_19 NBLB_B[1]_20 NBLB_B[1]_21 NBLB_B[1]_22 NBLB_B[1]_23
+  NBLB_B[1]_24 NBLB_B[1]_25 NBLB_B[1]_26 NBLB_B[1]_27 NBLB_B[1]_28
+  NBLB_B[1]_29 NBLB_B[1]_30 NBLB_B[1]_31 NBLB_B[1]_32 NBLB_B[1]_33
+  NBLB_B[1]_34 NBLB_B[1]_35 NBLB_B[1]_36 NBLB_B[1]_37 NBLB_B[1]_38
+  NBLB_B[1]_39 NBLB_B[1]_40 NBLB_B[1]_41 NBLB_B[1]_42 NBLB_B[1]_43
+  NBLB_B[1]_44 NBLB_B[1]_45 NBLB_B[1]_46 NBLB_B[1]_47 NBLB_B[1]_48
+  NBLB_B[1]_49 NBLB_B[1]_50 NBLB_B[1]_51 NBLB_B[1]_52 NBLB_B[1]_53
+  NBLB_B[1]_54 NBLB_B[1]_55 NBLB_B[1]_56 NBLB_B[1]_57 NBLB_B[1]_58
+  NBLB_B[1]_59 NBLB_B[1]_60 NBLB_B[1]_61 NBLB_B[1]_62 NBLB_B[1]_63
+  NBLB_B[2]_0 NBLB_B[2]_1 NBLB_B[2]_2 NBLB_B[2]_3 NBLB_B[2]_4 NBLB_B[2]_5
+  NBLB_B[2]_6 NBLB_B[2]_7 NBLB_B[2]_8 NBLB_B[2]_9 NBLB_B[2]_10 NBLB_B[2]_11
+  NBLB_B[2]_12 NBLB_B[2]_13 NBLB_B[2]_14 NBLB_B[2]_15 NBLB_B[2]_16
+  NBLB_B[2]_17 NBLB_B[2]_18 NBLB_B[2]_19 NBLB_B[2]_20 NBLB_B[2]_21
+  NBLB_B[2]_22 NBLB_B[2]_23 NBLB_B[2]_24 NBLB_B[2]_25 NBLB_B[2]_26
+  NBLB_B[2]_27 NBLB_B[2]_28 NBLB_B[2]_29 NBLB_B[2]_30 NBLB_B[2]_31
+  NBLB_B[2]_32 NBLB_B[2]_33 NBLB_B[2]_34 NBLB_B[2]_35 NBLB_B[2]_36
+  NBLB_B[2]_37 NBLB_B[2]_38 NBLB_B[2]_39 NBLB_B[2]_40 NBLB_B[2]_41
+  NBLB_B[2]_42 NBLB_B[2]_43 NBLB_B[2]_44 NBLB_B[2]_45 NBLB_B[2]_46
+  NBLB_B[2]_47 NBLB_B[2]_48 NBLB_B[2]_49 NBLB_B[2]_50 NBLB_B[2]_51
+  NBLB_B[2]_52 NBLB_B[2]_53 NBLB_B[2]_54 NBLB_B[2]_55 NBLB_B[2]_56
+  NBLB_B[2]_57 NBLB_B[2]_58 NBLB_B[2]_59 NBLB_B[2]_60 NBLB_B[2]_61
+  NBLB_B[2]_62 NBLB_B[2]_63 NBLB_B[3]_0 NBLB_B[3]_1 NBLB_B[3]_2 NBLB_B[3]_3
+  NBLB_B[3]_4 NBLB_B[3]_5 NBLB_B[3]_6 NBLB_B[3]_7 NBLB_B[3]_8 NBLB_B[3]_9
+  NBLB_B[3]_10 NBLB_B[3]_11 NBLB_B[3]_12 NBLB_B[3]_13 NBLB_B[3]_14
+  NBLB_B[3]_15 NBLB_B[3]_16 NBLB_B[3]_17 NBLB_B[3]_18 NBLB_B[3]_19
+  NBLB_B[3]_20 NBLB_B[3]_21 NBLB_B[3]_22 NBLB_B[3]_23 NBLB_B[3]_24
+  NBLB_B[3]_25 NBLB_B[3]_26 NBLB_B[3]_27 NBLB_B[3]_28 NBLB_B[3]_29
+  NBLB_B[3]_30 NBLB_B[3]_31 NBLB_B[3]_32 NBLB_B[3]_33 NBLB_B[3]_34
+  NBLB_B[3]_35 NBLB_B[3]_36 NBLB_B[3]_37 NBLB_B[3]_38 NBLB_B[3]_39
+  NBLB_B[3]_40 NBLB_B[3]_41 NBLB_B[3]_42 NBLB_B[3]_43 NBLB_B[3]_44
+  NBLB_B[3]_45 NBLB_B[3]_46 NBLB_B[3]_47 NBLB_B[3]_48 NBLB_B[3]_49
+  NBLB_B[3]_50 NBLB_B[3]_51 NBLB_B[3]_52 NBLB_B[3]_53 NBLB_B[3]_54
+  NBLB_B[3]_55 NBLB_B[3]_56 NBLB_B[3]_57 NBLB_B[3]_58 NBLB_B[3]_59
+  NBLB_B[3]_60 NBLB_B[3]_61 NBLB_B[3]_62 NBLB_B[3]_63 NDFTRAMBYP_A
+  NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0
+  NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6
+  NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12
+  NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18
+  NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24
+  NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30
+  NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36
+  NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42
+  NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48
+  NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54
+  NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60
+  NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2
+  NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8
+  NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14
+  NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20
+  NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26
+  NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32
+  NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38
+  NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44
+  NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50
+  NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56
+  NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62
+  NWGSEL_B_63 NWL_CLKB_A NWL_CLKB_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2]
+  NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7]
+  NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4]
+  NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1]
+  NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6]
+  NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3]
+  NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0]
+  NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1]
+  NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RE_A RE_B VDDCA
+  VDDCB VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7
+  VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63
+  VNWC VNWP VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256COLMXDN32320: 20387 flat devices **
XCMUXSA_EDGE NACT_B NACT_T NC_NDSA_TP_A NC_NDSA_TP_B NC_NRSEL_A[0]
+  NC_NRSEL_A[1] NC_NRSEL_A[2] NC_NRSEL_A[3] NC_NRSEL_B[0] NC_NRSEL_B[1]
+  NC_NRSEL_B[2] NC_NRSEL_B[3] NC_NWSEL_A[0] NC_NWSEL_A[1] NC_NWSEL_A[2]
+  NC_NWSEL_A[3] NC_NWSEL_B[0] NC_NWSEL_B[1] NC_NWSEL_B[2] NC_NWSEL_B[3]
+  NC_PCH_BL_B_A NC_PCH_BL_B_B NC_RDA_OVRDB NC_RDB_OVRDB NC_SA_TP_A NC_SA_TP_B
+  NWCLK_WT_A NWCLK_WT_B SA_TIELO VNWP VNWC VNWP VPW VPW SRAMdpw64d256EDGE_CM
XI4 NACT_FDBK_B NACT_T_29 NC_NDSA_TP_A NC_NDSA_TP_B NC_NRSEL_A[0]
+  NC_NRSEL_A[1] NC_NRSEL_A[2] NC_NRSEL_A[3] NC_NRSEL_B[0] NC_NRSEL_B[1]
+  NC_NRSEL_B[2] NC_NRSEL_B[3] NC_NWSEL_A[0] NC_NWSEL_A[1] NC_NWSEL_A[2]
+  NC_NWSEL_A[3] NC_NWSEL_B[0] NC_NWSEL_B[1] NC_NWSEL_B[2] NC_NWSEL_B[3]
+  PCH_BL_B_A PCH_BL_B_B NC_RDA_OVRDB NC_RDB_OVRDB NC_SA_TP_A NC_SA_TP_B
+  NWCLK_WT_A NWCLK_WT_B SA_TIELO VNWP VNWC VNWP VPW VPW SRAMdpw64d256EDGE_CM
XINNERSUBCHANNEL BLB_A[0]_32 BLB_A[0]_33 BLB_A[0]_34 BLB_A[0]_35 BLB_A[0]_36
+  BLB_A[0]_37 BLB_A[0]_38 BLB_A[0]_39 BLB_A[0]_40 BLB_A[0]_41 BLB_A[0]_42
+  BLB_A[0]_43 BLB_A[0]_44 BLB_A[0]_45 BLB_A[0]_46 BLB_A[0]_47 BLB_A[0]_48
+  BLB_A[0]_49 BLB_A[0]_50 BLB_A[0]_51 BLB_A[0]_52 BLB_A[0]_53 BLB_A[0]_54
+  BLB_A[0]_55 BLB_A[0]_56 BLB_A[0]_57 BLB_A[0]_58 BLB_A[0]_59 BLB_A[0]_60
+  BLB_A[0]_61 BLB_A[0]_62 BLB_A[0]_63 BLB_A[1]_32 BLB_A[1]_33 BLB_A[1]_34
+  BLB_A[1]_35 BLB_A[1]_36 BLB_A[1]_37 BLB_A[1]_38 BLB_A[1]_39 BLB_A[1]_40
+  BLB_A[1]_41 BLB_A[1]_42 BLB_A[1]_43 BLB_A[1]_44 BLB_A[1]_45 BLB_A[1]_46
+  BLB_A[1]_47 BLB_A[1]_48 BLB_A[1]_49 BLB_A[1]_50 BLB_A[1]_51 BLB_A[1]_52
+  BLB_A[1]_53 BLB_A[1]_54 BLB_A[1]_55 BLB_A[1]_56 BLB_A[1]_57 BLB_A[1]_58
+  BLB_A[1]_59 BLB_A[1]_60 BLB_A[1]_61 BLB_A[1]_62 BLB_A[1]_63 BLB_A[2]_32
+  BLB_A[2]_33 BLB_A[2]_34 BLB_A[2]_35 BLB_A[2]_36 BLB_A[2]_37 BLB_A[2]_38
+  BLB_A[2]_39 BLB_A[2]_40 BLB_A[2]_41 BLB_A[2]_42 BLB_A[2]_43 BLB_A[2]_44
+  BLB_A[2]_45 BLB_A[2]_46 BLB_A[2]_47 BLB_A[2]_48 BLB_A[2]_49 BLB_A[2]_50
+  BLB_A[2]_51 BLB_A[2]_52 BLB_A[2]_53 BLB_A[2]_54 BLB_A[2]_55 BLB_A[2]_56
+  BLB_A[2]_57 BLB_A[2]_58 BLB_A[2]_59 BLB_A[2]_60 BLB_A[2]_61 BLB_A[2]_62
+  BLB_A[2]_63 BLB_A[3]_32 BLB_A[3]_33 BLB_A[3]_34 BLB_A[3]_35 BLB_A[3]_36
+  BLB_A[3]_37 BLB_A[3]_38 BLB_A[3]_39 BLB_A[3]_40 BLB_A[3]_41 BLB_A[3]_42
+  BLB_A[3]_43 BLB_A[3]_44 BLB_A[3]_45 BLB_A[3]_46 BLB_A[3]_47 BLB_A[3]_48
+  BLB_A[3]_49 BLB_A[3]_50 BLB_A[3]_51 BLB_A[3]_52 BLB_A[3]_53 BLB_A[3]_54
+  BLB_A[3]_55 BLB_A[3]_56 BLB_A[3]_57 BLB_A[3]_58 BLB_A[3]_59 BLB_A[3]_60
+  BLB_A[3]_61 BLB_A[3]_62 BLB_A[3]_63 BLB_B[0]_32 BLB_B[0]_33 BLB_B[0]_34
+  BLB_B[0]_35 BLB_B[0]_36 BLB_B[0]_37 BLB_B[0]_38 BLB_B[0]_39 BLB_B[0]_40
+  BLB_B[0]_41 BLB_B[0]_42 BLB_B[0]_43 BLB_B[0]_44 BLB_B[0]_45 BLB_B[0]_46
+  BLB_B[0]_47 BLB_B[0]_48 BLB_B[0]_49 BLB_B[0]_50 BLB_B[0]_51 BLB_B[0]_52
+  BLB_B[0]_53 BLB_B[0]_54 BLB_B[0]_55 BLB_B[0]_56 BLB_B[0]_57 BLB_B[0]_58
+  BLB_B[0]_59 BLB_B[0]_60 BLB_B[0]_61 BLB_B[0]_62 BLB_B[0]_63 BLB_B[1]_32
+  BLB_B[1]_33 BLB_B[1]_34 BLB_B[1]_35 BLB_B[1]_36 BLB_B[1]_37 BLB_B[1]_38
+  BLB_B[1]_39 BLB_B[1]_40 BLB_B[1]_41 BLB_B[1]_42 BLB_B[1]_43 BLB_B[1]_44
+  BLB_B[1]_45 BLB_B[1]_46 BLB_B[1]_47 BLB_B[1]_48 BLB_B[1]_49 BLB_B[1]_50
+  BLB_B[1]_51 BLB_B[1]_52 BLB_B[1]_53 BLB_B[1]_54 BLB_B[1]_55 BLB_B[1]_56
+  BLB_B[1]_57 BLB_B[1]_58 BLB_B[1]_59 BLB_B[1]_60 BLB_B[1]_61 BLB_B[1]_62
+  BLB_B[1]_63 BLB_B[2]_32 BLB_B[2]_33 BLB_B[2]_34 BLB_B[2]_35 BLB_B[2]_36
+  BLB_B[2]_37 BLB_B[2]_38 BLB_B[2]_39 BLB_B[2]_40 BLB_B[2]_41 BLB_B[2]_42
+  BLB_B[2]_43 BLB_B[2]_44 BLB_B[2]_45 BLB_B[2]_46 BLB_B[2]_47 BLB_B[2]_48
+  BLB_B[2]_49 BLB_B[2]_50 BLB_B[2]_51 BLB_B[2]_52 BLB_B[2]_53 BLB_B[2]_54
+  BLB_B[2]_55 BLB_B[2]_56 BLB_B[2]_57 BLB_B[2]_58 BLB_B[2]_59 BLB_B[2]_60
+  BLB_B[2]_61 BLB_B[2]_62 BLB_B[2]_63 BLB_B[3]_32 BLB_B[3]_33 BLB_B[3]_34
+  BLB_B[3]_35 BLB_B[3]_36 BLB_B[3]_37 BLB_B[3]_38 BLB_B[3]_39 BLB_B[3]_40
+  BLB_B[3]_41 BLB_B[3]_42 BLB_B[3]_43 BLB_B[3]_44 BLB_B[3]_45 BLB_B[3]_46
+  BLB_B[3]_47 BLB_B[3]_48 BLB_B[3]_49 BLB_B[3]_50 BLB_B[3]_51 BLB_B[3]_52
+  BLB_B[3]_53 BLB_B[3]_54 BLB_B[3]_55 BLB_B[3]_56 BLB_B[3]_57 BLB_B[3]_58
+  BLB_B[3]_59 BLB_B[3]_60 BLB_B[3]_61 BLB_B[3]_62 BLB_B[3]_63 DATAIN_A_32
+  DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38
+  DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44
+  DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50
+  DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56
+  DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62
+  DATAIN_A_63 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36
+  DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42
+  DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48
+  DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54
+  DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60
+  DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35
+  GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43
+  GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51
+  GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59
+  GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35
+  GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43
+  GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51
+  GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59
+  GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 NACT_FDBK_B NACT_FDBK_B NACT_T_29
+  NACT_T_29 NBLB_A[0]_32 NBLB_A[0]_33 NBLB_A[0]_34 NBLB_A[0]_35 NBLB_A[0]_36
+  NBLB_A[0]_37 NBLB_A[0]_38 NBLB_A[0]_39 NBLB_A[0]_40 NBLB_A[0]_41
+  NBLB_A[0]_42 NBLB_A[0]_43 NBLB_A[0]_44 NBLB_A[0]_45 NBLB_A[0]_46
+  NBLB_A[0]_47 NBLB_A[0]_48 NBLB_A[0]_49 NBLB_A[0]_50 NBLB_A[0]_51
+  NBLB_A[0]_52 NBLB_A[0]_53 NBLB_A[0]_54 NBLB_A[0]_55 NBLB_A[0]_56
+  NBLB_A[0]_57 NBLB_A[0]_58 NBLB_A[0]_59 NBLB_A[0]_60 NBLB_A[0]_61
+  NBLB_A[0]_62 NBLB_A[0]_63 NBLB_A[1]_32 NBLB_A[1]_33 NBLB_A[1]_34
+  NBLB_A[1]_35 NBLB_A[1]_36 NBLB_A[1]_37 NBLB_A[1]_38 NBLB_A[1]_39
+  NBLB_A[1]_40 NBLB_A[1]_41 NBLB_A[1]_42 NBLB_A[1]_43 NBLB_A[1]_44
+  NBLB_A[1]_45 NBLB_A[1]_46 NBLB_A[1]_47 NBLB_A[1]_48 NBLB_A[1]_49
+  NBLB_A[1]_50 NBLB_A[1]_51 NBLB_A[1]_52 NBLB_A[1]_53 NBLB_A[1]_54
+  NBLB_A[1]_55 NBLB_A[1]_56 NBLB_A[1]_57 NBLB_A[1]_58 NBLB_A[1]_59
+  NBLB_A[1]_60 NBLB_A[1]_61 NBLB_A[1]_62 NBLB_A[1]_63 NBLB_A[2]_32
+  NBLB_A[2]_33 NBLB_A[2]_34 NBLB_A[2]_35 NBLB_A[2]_36 NBLB_A[2]_37
+  NBLB_A[2]_38 NBLB_A[2]_39 NBLB_A[2]_40 NBLB_A[2]_41 NBLB_A[2]_42
+  NBLB_A[2]_43 NBLB_A[2]_44 NBLB_A[2]_45 NBLB_A[2]_46 NBLB_A[2]_47
+  NBLB_A[2]_48 NBLB_A[2]_49 NBLB_A[2]_50 NBLB_A[2]_51 NBLB_A[2]_52
+  NBLB_A[2]_53 NBLB_A[2]_54 NBLB_A[2]_55 NBLB_A[2]_56 NBLB_A[2]_57
+  NBLB_A[2]_58 NBLB_A[2]_59 NBLB_A[2]_60 NBLB_A[2]_61 NBLB_A[2]_62
+  NBLB_A[2]_63 NBLB_A[3]_32 NBLB_A[3]_33 NBLB_A[3]_34 NBLB_A[3]_35
+  NBLB_A[3]_36 NBLB_A[3]_37 NBLB_A[3]_38 NBLB_A[3]_39 NBLB_A[3]_40
+  NBLB_A[3]_41 NBLB_A[3]_42 NBLB_A[3]_43 NBLB_A[3]_44 NBLB_A[3]_45
+  NBLB_A[3]_46 NBLB_A[3]_47 NBLB_A[3]_48 NBLB_A[3]_49 NBLB_A[3]_50
+  NBLB_A[3]_51 NBLB_A[3]_52 NBLB_A[3]_53 NBLB_A[3]_54 NBLB_A[3]_55
+  NBLB_A[3]_56 NBLB_A[3]_57 NBLB_A[3]_58 NBLB_A[3]_59 NBLB_A[3]_60
+  NBLB_A[3]_61 NBLB_A[3]_62 NBLB_A[3]_63 NBLB_B[0]_32 NBLB_B[0]_33
+  NBLB_B[0]_34 NBLB_B[0]_35 NBLB_B[0]_36 NBLB_B[0]_37 NBLB_B[0]_38
+  NBLB_B[0]_39 NBLB_B[0]_40 NBLB_B[0]_41 NBLB_B[0]_42 NBLB_B[0]_43
+  NBLB_B[0]_44 NBLB_B[0]_45 NBLB_B[0]_46 NBLB_B[0]_47 NBLB_B[0]_48
+  NBLB_B[0]_49 NBLB_B[0]_50 NBLB_B[0]_51 NBLB_B[0]_52 NBLB_B[0]_53
+  NBLB_B[0]_54 NBLB_B[0]_55 NBLB_B[0]_56 NBLB_B[0]_57 NBLB_B[0]_58
+  NBLB_B[0]_59 NBLB_B[0]_60 NBLB_B[0]_61 NBLB_B[0]_62 NBLB_B[0]_63
+  NBLB_B[1]_32 NBLB_B[1]_33 NBLB_B[1]_34 NBLB_B[1]_35 NBLB_B[1]_36
+  NBLB_B[1]_37 NBLB_B[1]_38 NBLB_B[1]_39 NBLB_B[1]_40 NBLB_B[1]_41
+  NBLB_B[1]_42 NBLB_B[1]_43 NBLB_B[1]_44 NBLB_B[1]_45 NBLB_B[1]_46
+  NBLB_B[1]_47 NBLB_B[1]_48 NBLB_B[1]_49 NBLB_B[1]_50 NBLB_B[1]_51
+  NBLB_B[1]_52 NBLB_B[1]_53 NBLB_B[1]_54 NBLB_B[1]_55 NBLB_B[1]_56
+  NBLB_B[1]_57 NBLB_B[1]_58 NBLB_B[1]_59 NBLB_B[1]_60 NBLB_B[1]_61
+  NBLB_B[1]_62 NBLB_B[1]_63 NBLB_B[2]_32 NBLB_B[2]_33 NBLB_B[2]_34
+  NBLB_B[2]_35 NBLB_B[2]_36 NBLB_B[2]_37 NBLB_B[2]_38 NBLB_B[2]_39
+  NBLB_B[2]_40 NBLB_B[2]_41 NBLB_B[2]_42 NBLB_B[2]_43 NBLB_B[2]_44
+  NBLB_B[2]_45 NBLB_B[2]_46 NBLB_B[2]_47 NBLB_B[2]_48 NBLB_B[2]_49
+  NBLB_B[2]_50 NBLB_B[2]_51 NBLB_B[2]_52 NBLB_B[2]_53 NBLB_B[2]_54
+  NBLB_B[2]_55 NBLB_B[2]_56 NBLB_B[2]_57 NBLB_B[2]_58 NBLB_B[2]_59
+  NBLB_B[2]_60 NBLB_B[2]_61 NBLB_B[2]_62 NBLB_B[2]_63 NBLB_B[3]_32
+  NBLB_B[3]_33 NBLB_B[3]_34 NBLB_B[3]_35 NBLB_B[3]_36 NBLB_B[3]_37
+  NBLB_B[3]_38 NBLB_B[3]_39 NBLB_B[3]_40 NBLB_B[3]_41 NBLB_B[3]_42
+  NBLB_B[3]_43 NBLB_B[3]_44 NBLB_B[3]_45 NBLB_B[3]_46 NBLB_B[3]_47
+  NBLB_B[3]_48 NBLB_B[3]_49 NBLB_B[3]_50 NBLB_B[3]_51 NBLB_B[3]_52
+  NBLB_B[3]_53 NBLB_B[3]_54 NBLB_B[3]_55 NBLB_B[3]_56 NBLB_B[3]_57
+  NBLB_B[3]_58 NBLB_B[3]_59 NBLB_B[3]_60 NBLB_B[3]_61 NBLB_B[3]_62
+  NBLB_B[3]_63 NC_NDSA_TP_A NC_NDSA_TP_B NC_NRSEL_A[0] NC_NRSEL_A[1]
+  NC_NRSEL_A[2] NC_NRSEL_A[3] NC_NRSEL_B[0] NC_NRSEL_B[1] NC_NRSEL_B[2]
+  NC_NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34
+  NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40
+  NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46
+  NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52
+  NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58
+  NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_32
+  NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38
+  NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44
+  NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50
+  NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56
+  NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62
+  NWGSEL_B_63 NC_NWSEL_A[0] NC_NWSEL_A[1] NC_NWSEL_A[2] NC_NWSEL_A[3]
+  NC_NWSEL_B[0] NC_NWSEL_B[1] NC_NWSEL_B[2] NC_NWSEL_B[3] PCH_BL_B_A
+  PCH_BL_B_B NC_RDA_OVRDB NC_RDB_OVRDB SA_TIELO NC_SA_TP_A NC_SA_TP_B
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47
+  VDDCE_48 VDDCE_49 VDDCE_50 VDDCE_51 VDDCE_52 VDDCE_53 VDDCE_54 VDDCE_55
+  VDDCE_56 VDDCE_57 VDDCE_58 VDDCE_59 VDDCE_60 VDDCE_61 VDDCE_62 VDDCE_63
+  VNWP VNWC VPW SRAMdpw64d256COLMX0DN32O
XOUTERSUBCHANNEL BLB_A[0]_31 BLB_A[0]_30 BLB_A[0]_29 BLB_A[0]_28 BLB_A[0]_27
+  BLB_A[0]_26 BLB_A[0]_25 BLB_A[0]_24 BLB_A[0]_23 BLB_A[0]_22 BLB_A[0]_21
+  BLB_A[0]_20 BLB_A[0]_19 BLB_A[0]_18 BLB_A[0]_17 BLB_A[0]_16 BLB_A[0]_15
+  BLB_A[0]_14 BLB_A[0]_13 BLB_A[0]_12 BLB_A[0]_11 BLB_A[0]_10 BLB_A[0]_9
+  BLB_A[0]_8 BLB_A[0]_7 BLB_A[0]_6 BLB_A[0]_5 BLB_A[0]_4 BLB_A[0]_3
+  BLB_A[0]_2 BLB_A[0]_1 BLB_A[0]_0 BLB_A[1]_31 BLB_A[1]_30 BLB_A[1]_29
+  BLB_A[1]_28 BLB_A[1]_27 BLB_A[1]_26 BLB_A[1]_25 BLB_A[1]_24 BLB_A[1]_23
+  BLB_A[1]_22 BLB_A[1]_21 BLB_A[1]_20 BLB_A[1]_19 BLB_A[1]_18 BLB_A[1]_17
+  BLB_A[1]_16 BLB_A[1]_15 BLB_A[1]_14 BLB_A[1]_13 BLB_A[1]_12 BLB_A[1]_11
+  BLB_A[1]_10 BLB_A[1]_9 BLB_A[1]_8 BLB_A[1]_7 BLB_A[1]_6 BLB_A[1]_5
+  BLB_A[1]_4 BLB_A[1]_3 BLB_A[1]_2 BLB_A[1]_1 BLB_A[1]_0 BLB_A[2]_31
+  BLB_A[2]_30 BLB_A[2]_29 BLB_A[2]_28 BLB_A[2]_27 BLB_A[2]_26 BLB_A[2]_25
+  BLB_A[2]_24 BLB_A[2]_23 BLB_A[2]_22 BLB_A[2]_21 BLB_A[2]_20 BLB_A[2]_19
+  BLB_A[2]_18 BLB_A[2]_17 BLB_A[2]_16 BLB_A[2]_15 BLB_A[2]_14 BLB_A[2]_13
+  BLB_A[2]_12 BLB_A[2]_11 BLB_A[2]_10 BLB_A[2]_9 BLB_A[2]_8 BLB_A[2]_7
+  BLB_A[2]_6 BLB_A[2]_5 BLB_A[2]_4 BLB_A[2]_3 BLB_A[2]_2 BLB_A[2]_1
+  BLB_A[2]_0 BLB_A[3]_31 BLB_A[3]_30 BLB_A[3]_29 BLB_A[3]_28 BLB_A[3]_27
+  BLB_A[3]_26 BLB_A[3]_25 BLB_A[3]_24 BLB_A[3]_23 BLB_A[3]_22 BLB_A[3]_21
+  BLB_A[3]_20 BLB_A[3]_19 BLB_A[3]_18 BLB_A[3]_17 BLB_A[3]_16 BLB_A[3]_15
+  BLB_A[3]_14 BLB_A[3]_13 BLB_A[3]_12 BLB_A[3]_11 BLB_A[3]_10 BLB_A[3]_9
+  BLB_A[3]_8 BLB_A[3]_7 BLB_A[3]_6 BLB_A[3]_5 BLB_A[3]_4 BLB_A[3]_3
+  BLB_A[3]_2 BLB_A[3]_1 BLB_A[3]_0 BLB_B[0]_31 BLB_B[0]_30 BLB_B[0]_29
+  BLB_B[0]_28 BLB_B[0]_27 BLB_B[0]_26 BLB_B[0]_25 BLB_B[0]_24 BLB_B[0]_23
+  BLB_B[0]_22 BLB_B[0]_21 BLB_B[0]_20 BLB_B[0]_19 BLB_B[0]_18 BLB_B[0]_17
+  BLB_B[0]_16 BLB_B[0]_15 BLB_B[0]_14 BLB_B[0]_13 BLB_B[0]_12 BLB_B[0]_11
+  BLB_B[0]_10 BLB_B[0]_9 BLB_B[0]_8 BLB_B[0]_7 BLB_B[0]_6 BLB_B[0]_5
+  BLB_B[0]_4 BLB_B[0]_3 BLB_B[0]_2 BLB_B[0]_1 BLB_B[0]_0 BLB_B[1]_31
+  BLB_B[1]_30 BLB_B[1]_29 BLB_B[1]_28 BLB_B[1]_27 BLB_B[1]_26 BLB_B[1]_25
+  BLB_B[1]_24 BLB_B[1]_23 BLB_B[1]_22 BLB_B[1]_21 BLB_B[1]_20 BLB_B[1]_19
+  BLB_B[1]_18 BLB_B[1]_17 BLB_B[1]_16 BLB_B[1]_15 BLB_B[1]_14 BLB_B[1]_13
+  BLB_B[1]_12 BLB_B[1]_11 BLB_B[1]_10 BLB_B[1]_9 BLB_B[1]_8 BLB_B[1]_7
+  BLB_B[1]_6 BLB_B[1]_5 BLB_B[1]_4 BLB_B[1]_3 BLB_B[1]_2 BLB_B[1]_1
+  BLB_B[1]_0 BLB_B[2]_31 BLB_B[2]_30 BLB_B[2]_29 BLB_B[2]_28 BLB_B[2]_27
+  BLB_B[2]_26 BLB_B[2]_25 BLB_B[2]_24 BLB_B[2]_23 BLB_B[2]_22 BLB_B[2]_21
+  BLB_B[2]_20 BLB_B[2]_19 BLB_B[2]_18 BLB_B[2]_17 BLB_B[2]_16 BLB_B[2]_15
+  BLB_B[2]_14 BLB_B[2]_13 BLB_B[2]_12 BLB_B[2]_11 BLB_B[2]_10 BLB_B[2]_9
+  BLB_B[2]_8 BLB_B[2]_7 BLB_B[2]_6 BLB_B[2]_5 BLB_B[2]_4 BLB_B[2]_3
+  BLB_B[2]_2 BLB_B[2]_1 BLB_B[2]_0 BLB_B[3]_31 BLB_B[3]_30 BLB_B[3]_29
+  BLB_B[3]_28 BLB_B[3]_27 BLB_B[3]_26 BLB_B[3]_25 BLB_B[3]_24 BLB_B[3]_23
+  BLB_B[3]_22 BLB_B[3]_21 BLB_B[3]_20 BLB_B[3]_19 BLB_B[3]_18 BLB_B[3]_17
+  BLB_B[3]_16 BLB_B[3]_15 BLB_B[3]_14 BLB_B[3]_13 BLB_B[3]_12 BLB_B[3]_11
+  BLB_B[3]_10 BLB_B[3]_9 BLB_B[3]_8 BLB_B[3]_7 BLB_B[3]_6 BLB_B[3]_5
+  BLB_B[3]_4 BLB_B[3]_3 BLB_B[3]_2 BLB_B[3]_1 BLB_B[3]_0 DATAIN_A_31
+  DATAIN_A_30 DATAIN_A_29 DATAIN_A_28 DATAIN_A_27 DATAIN_A_26 DATAIN_A_25
+  DATAIN_A_24 DATAIN_A_23 DATAIN_A_22 DATAIN_A_21 DATAIN_A_20 DATAIN_A_19
+  DATAIN_A_18 DATAIN_A_17 DATAIN_A_16 DATAIN_A_15 DATAIN_A_14 DATAIN_A_13
+  DATAIN_A_12 DATAIN_A_11 DATAIN_A_10 DATAIN_A_9 DATAIN_A_8 DATAIN_A_7
+  DATAIN_A_6 DATAIN_A_5 DATAIN_A_4 DATAIN_A_3 DATAIN_A_2 DATAIN_A_1
+  DATAIN_A_0 DATAIN_B_31 DATAIN_B_30 DATAIN_B_29 DATAIN_B_28 DATAIN_B_27
+  DATAIN_B_26 DATAIN_B_25 DATAIN_B_24 DATAIN_B_23 DATAIN_B_22 DATAIN_B_21
+  DATAIN_B_20 DATAIN_B_19 DATAIN_B_18 DATAIN_B_17 DATAIN_B_16 DATAIN_B_15
+  DATAIN_B_14 DATAIN_B_13 DATAIN_B_12 DATAIN_B_11 DATAIN_B_10 DATAIN_B_9
+  DATAIN_B_8 DATAIN_B_7 DATAIN_B_6 DATAIN_B_5 DATAIN_B_4 DATAIN_B_3
+  DATAIN_B_2 DATAIN_B_1 DATAIN_B_0 GDL_A_31 GDL_A_30 GDL_A_29 GDL_A_28
+  GDL_A_27 GDL_A_26 GDL_A_25 GDL_A_24 GDL_A_23 GDL_A_22 GDL_A_21 GDL_A_20
+  GDL_A_19 GDL_A_18 GDL_A_17 GDL_A_16 GDL_A_15 GDL_A_14 GDL_A_13 GDL_A_12
+  GDL_A_11 GDL_A_10 GDL_A_9 GDL_A_8 GDL_A_7 GDL_A_6 GDL_A_5 GDL_A_4 GDL_A_3
+  GDL_A_2 GDL_A_1 GDL_A_0 GDL_B_31 GDL_B_30 GDL_B_29 GDL_B_28 GDL_B_27
+  GDL_B_26 GDL_B_25 GDL_B_24 GDL_B_23 GDL_B_22 GDL_B_21 GDL_B_20 GDL_B_19
+  GDL_B_18 GDL_B_17 GDL_B_16 GDL_B_15 GDL_B_14 GDL_B_13 GDL_B_12 GDL_B_11
+  GDL_B_10 GDL_B_9 GDL_B_8 GDL_B_7 GDL_B_6 GDL_B_5 GDL_B_4 GDL_B_3 GDL_B_2
+  GDL_B_1 GDL_B_0 NACT_B NACT_B NACT_T NACT_T NBLB_A[0]_31 NBLB_A[0]_30
+  NBLB_A[0]_29 NBLB_A[0]_28 NBLB_A[0]_27 NBLB_A[0]_26 NBLB_A[0]_25
+  NBLB_A[0]_24 NBLB_A[0]_23 NBLB_A[0]_22 NBLB_A[0]_21 NBLB_A[0]_20
+  NBLB_A[0]_19 NBLB_A[0]_18 NBLB_A[0]_17 NBLB_A[0]_16 NBLB_A[0]_15
+  NBLB_A[0]_14 NBLB_A[0]_13 NBLB_A[0]_12 NBLB_A[0]_11 NBLB_A[0]_10
+  NBLB_A[0]_9 NBLB_A[0]_8 NBLB_A[0]_7 NBLB_A[0]_6 NBLB_A[0]_5 NBLB_A[0]_4
+  NBLB_A[0]_3 NBLB_A[0]_2 NBLB_A[0]_1 NBLB_A[0]_0 NBLB_A[1]_31 NBLB_A[1]_30
+  NBLB_A[1]_29 NBLB_A[1]_28 NBLB_A[1]_27 NBLB_A[1]_26 NBLB_A[1]_25
+  NBLB_A[1]_24 NBLB_A[1]_23 NBLB_A[1]_22 NBLB_A[1]_21 NBLB_A[1]_20
+  NBLB_A[1]_19 NBLB_A[1]_18 NBLB_A[1]_17 NBLB_A[1]_16 NBLB_A[1]_15
+  NBLB_A[1]_14 NBLB_A[1]_13 NBLB_A[1]_12 NBLB_A[1]_11 NBLB_A[1]_10
+  NBLB_A[1]_9 NBLB_A[1]_8 NBLB_A[1]_7 NBLB_A[1]_6 NBLB_A[1]_5 NBLB_A[1]_4
+  NBLB_A[1]_3 NBLB_A[1]_2 NBLB_A[1]_1 NBLB_A[1]_0 NBLB_A[2]_31 NBLB_A[2]_30
+  NBLB_A[2]_29 NBLB_A[2]_28 NBLB_A[2]_27 NBLB_A[2]_26 NBLB_A[2]_25
+  NBLB_A[2]_24 NBLB_A[2]_23 NBLB_A[2]_22 NBLB_A[2]_21 NBLB_A[2]_20
+  NBLB_A[2]_19 NBLB_A[2]_18 NBLB_A[2]_17 NBLB_A[2]_16 NBLB_A[2]_15
+  NBLB_A[2]_14 NBLB_A[2]_13 NBLB_A[2]_12 NBLB_A[2]_11 NBLB_A[2]_10
+  NBLB_A[2]_9 NBLB_A[2]_8 NBLB_A[2]_7 NBLB_A[2]_6 NBLB_A[2]_5 NBLB_A[2]_4
+  NBLB_A[2]_3 NBLB_A[2]_2 NBLB_A[2]_1 NBLB_A[2]_0 NBLB_A[3]_31 NBLB_A[3]_30
+  NBLB_A[3]_29 NBLB_A[3]_28 NBLB_A[3]_27 NBLB_A[3]_26 NBLB_A[3]_25
+  NBLB_A[3]_24 NBLB_A[3]_23 NBLB_A[3]_22 NBLB_A[3]_21 NBLB_A[3]_20
+  NBLB_A[3]_19 NBLB_A[3]_18 NBLB_A[3]_17 NBLB_A[3]_16 NBLB_A[3]_15
+  NBLB_A[3]_14 NBLB_A[3]_13 NBLB_A[3]_12 NBLB_A[3]_11 NBLB_A[3]_10
+  NBLB_A[3]_9 NBLB_A[3]_8 NBLB_A[3]_7 NBLB_A[3]_6 NBLB_A[3]_5 NBLB_A[3]_4
+  NBLB_A[3]_3 NBLB_A[3]_2 NBLB_A[3]_1 NBLB_A[3]_0 NBLB_B[0]_31 NBLB_B[0]_30
+  NBLB_B[0]_29 NBLB_B[0]_28 NBLB_B[0]_27 NBLB_B[0]_26 NBLB_B[0]_25
+  NBLB_B[0]_24 NBLB_B[0]_23 NBLB_B[0]_22 NBLB_B[0]_21 NBLB_B[0]_20
+  NBLB_B[0]_19 NBLB_B[0]_18 NBLB_B[0]_17 NBLB_B[0]_16 NBLB_B[0]_15
+  NBLB_B[0]_14 NBLB_B[0]_13 NBLB_B[0]_12 NBLB_B[0]_11 NBLB_B[0]_10
+  NBLB_B[0]_9 NBLB_B[0]_8 NBLB_B[0]_7 NBLB_B[0]_6 NBLB_B[0]_5 NBLB_B[0]_4
+  NBLB_B[0]_3 NBLB_B[0]_2 NBLB_B[0]_1 NBLB_B[0]_0 NBLB_B[1]_31 NBLB_B[1]_30
+  NBLB_B[1]_29 NBLB_B[1]_28 NBLB_B[1]_27 NBLB_B[1]_26 NBLB_B[1]_25
+  NBLB_B[1]_24 NBLB_B[1]_23 NBLB_B[1]_22 NBLB_B[1]_21 NBLB_B[1]_20
+  NBLB_B[1]_19 NBLB_B[1]_18 NBLB_B[1]_17 NBLB_B[1]_16 NBLB_B[1]_15
+  NBLB_B[1]_14 NBLB_B[1]_13 NBLB_B[1]_12 NBLB_B[1]_11 NBLB_B[1]_10
+  NBLB_B[1]_9 NBLB_B[1]_8 NBLB_B[1]_7 NBLB_B[1]_6 NBLB_B[1]_5 NBLB_B[1]_4
+  NBLB_B[1]_3 NBLB_B[1]_2 NBLB_B[1]_1 NBLB_B[1]_0 NBLB_B[2]_31 NBLB_B[2]_30
+  NBLB_B[2]_29 NBLB_B[2]_28 NBLB_B[2]_27 NBLB_B[2]_26 NBLB_B[2]_25
+  NBLB_B[2]_24 NBLB_B[2]_23 NBLB_B[2]_22 NBLB_B[2]_21 NBLB_B[2]_20
+  NBLB_B[2]_19 NBLB_B[2]_18 NBLB_B[2]_17 NBLB_B[2]_16 NBLB_B[2]_15
+  NBLB_B[2]_14 NBLB_B[2]_13 NBLB_B[2]_12 NBLB_B[2]_11 NBLB_B[2]_10
+  NBLB_B[2]_9 NBLB_B[2]_8 NBLB_B[2]_7 NBLB_B[2]_6 NBLB_B[2]_5 NBLB_B[2]_4
+  NBLB_B[2]_3 NBLB_B[2]_2 NBLB_B[2]_1 NBLB_B[2]_0 NBLB_B[3]_31 NBLB_B[3]_30
+  NBLB_B[3]_29 NBLB_B[3]_28 NBLB_B[3]_27 NBLB_B[3]_26 NBLB_B[3]_25
+  NBLB_B[3]_24 NBLB_B[3]_23 NBLB_B[3]_22 NBLB_B[3]_21 NBLB_B[3]_20
+  NBLB_B[3]_19 NBLB_B[3]_18 NBLB_B[3]_17 NBLB_B[3]_16 NBLB_B[3]_15
+  NBLB_B[3]_14 NBLB_B[3]_13 NBLB_B[3]_12 NBLB_B[3]_11 NBLB_B[3]_10
+  NBLB_B[3]_9 NBLB_B[3]_8 NBLB_B[3]_7 NBLB_B[3]_6 NBLB_B[3]_5 NBLB_B[3]_4
+  NBLB_B[3]_3 NBLB_B[3]_2 NBLB_B[3]_1 NBLB_B[3]_0 NC_NDSA_TP_A NC_NDSA_TP_B
+  NC_NRSEL_A[0] NC_NRSEL_A[1] NC_NRSEL_A[2] NC_NRSEL_A[3] NC_NRSEL_B[0]
+  NC_NRSEL_B[1] NC_NRSEL_B[2] NC_NRSEL_B[3] NWCLK_WT_A NWCLK_WT_B NWGSEL_A_31
+  NWGSEL_A_30 NWGSEL_A_29 NWGSEL_A_28 NWGSEL_A_27 NWGSEL_A_26 NWGSEL_A_25
+  NWGSEL_A_24 NWGSEL_A_23 NWGSEL_A_22 NWGSEL_A_21 NWGSEL_A_20 NWGSEL_A_19
+  NWGSEL_A_18 NWGSEL_A_17 NWGSEL_A_16 NWGSEL_A_15 NWGSEL_A_14 NWGSEL_A_13
+  NWGSEL_A_12 NWGSEL_A_11 NWGSEL_A_10 NWGSEL_A_9 NWGSEL_A_8 NWGSEL_A_7
+  NWGSEL_A_6 NWGSEL_A_5 NWGSEL_A_4 NWGSEL_A_3 NWGSEL_A_2 NWGSEL_A_1
+  NWGSEL_A_0 NWGSEL_B_31 NWGSEL_B_30 NWGSEL_B_29 NWGSEL_B_28 NWGSEL_B_27
+  NWGSEL_B_26 NWGSEL_B_25 NWGSEL_B_24 NWGSEL_B_23 NWGSEL_B_22 NWGSEL_B_21
+  NWGSEL_B_20 NWGSEL_B_19 NWGSEL_B_18 NWGSEL_B_17 NWGSEL_B_16 NWGSEL_B_15
+  NWGSEL_B_14 NWGSEL_B_13 NWGSEL_B_12 NWGSEL_B_11 NWGSEL_B_10 NWGSEL_B_9
+  NWGSEL_B_8 NWGSEL_B_7 NWGSEL_B_6 NWGSEL_B_5 NWGSEL_B_4 NWGSEL_B_3
+  NWGSEL_B_2 NWGSEL_B_1 NWGSEL_B_0 NC_NWSEL_A[0] NC_NWSEL_A[1] NC_NWSEL_A[2]
+  NC_NWSEL_A[3] NC_NWSEL_B[0] NC_NWSEL_B[1] NC_NWSEL_B[2] NC_NWSEL_B[3]
+  NC_PCH_BL_B_A NC_PCH_BL_B_B NC_RDA_OVRDB NC_RDB_OVRDB SA_TIELO NC_SA_TP_A
+  NC_SA_TP_B VDDCE_31 VDDCE_30 VDDCE_29 VDDCE_28 VDDCE_27 VDDCE_26 VDDCE_25
+  VDDCE_24 VDDCE_23 VDDCE_22 VDDCE_21 VDDCE_20 VDDCE_19 VDDCE_18 VDDCE_17
+  VDDCE_16 VDDCE_15 VDDCE_14 VDDCE_13 VDDCE_12 VDDCE_11 VDDCE_10 VDDCE_9
+  VDDCE_8 VDDCE_7 VDDCE_6 VDDCE_5 VDDCE_4 VDDCE_3 VDDCE_2 VDDCE_1 VDDCE_0
+  VNWP VNWC VPW SRAMdpw64d256COLMX0DN32O
XTIMER ACTCLMP_A ACTCLMP_B BNK_A BNK_B CA_A[0] CA_A[1] CA_B[0] CA_B[1] CLK_A
+  CLK_B DBL_A DBL_B IACTCLMP_A IACTCLMP_B LOG0_DBL_A LOG0_DBL_B NACT NACT_B
+  NACT_T NACT_FDBK_B NACT_T_29 NACT_B NACT_T NACT_FDBK_B NACT_T_29
+  NDFTRAMBYP_A NDFTRAMBYP_B NC_NDSA_TP_A NC_NDSA_TP_B NHDR_WL_A NHDR_WL_B
+  NRDT_A NRDT_B NRETHVT NRETNVT NC_NRSEL_A[0] NC_NRSEL_A[1] NC_NRSEL_A[2]
+  NC_NRSEL_A[3] NC_NRSEL_B[0] NC_NRSEL_B[1] NC_NRSEL_B[2] NC_NRSEL_B[3]
+  NWCLK_WT_A NWCLK_WT_B NWL_CLKB_A NWL_CLKB_B NC_NWSEL_A[0] NC_NWSEL_A[1]
+  NC_NWSEL_A[2] NC_NWSEL_A[3] NC_NWSEL_B[0] NC_NWSEL_B[1] NC_NWSEL_B[2]
+  NC_NWSEL_B[3] NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3]
+  NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0]
+  NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5]
+  NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2]
+  NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7]
+  NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4]
+  NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1]
+  NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2]
+  NXPDEC3_B[3] NC_PCH_BL_B_A NC_PCH_BL_B_B PCH_BL_B_A PCH_BL_B_B NC_RDA_OVRDB
+  NC_RDB_OVRDB RETA[0] RETA[1] RETB[0] RETB[1] RE_A RE_B SA_TIELO NC_SA_TP_A
+  NC_SA_TP_B VDDCA VDDCB VNWC VNWP VNWC VNWP VPW VPW WE_A WE_B WRA_MA WRB_MA
+  WTE_A WTE_B SRAMdpw64d256TIMER
.ENDS SRAMdpw64d256COLMXDN32320
****
.SUBCKT SRAMdpw64d256SGAR0_64_32_32_0_S ACTCLMP_A_0 ACTCLMP_A_1 ACTCLMP_B_0
+  ACTCLMP_B_1 BNK_A BNK_B CA_A[0] CA_A[1] CA_B[0] CA_B[1] CLK_A CLK_B
+  DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5
+  DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11
+  DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17
+  DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23
+  DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29
+  DATAIN_A_30 DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35
+  DATAIN_A_36 DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41
+  DATAIN_A_42 DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47
+  DATAIN_A_48 DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53
+  DATAIN_A_54 DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59
+  DATAIN_A_60 DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1
+  DATAIN_B_2 DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7
+  DATAIN_B_8 DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13
+  DATAIN_B_14 DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19
+  DATAIN_B_20 DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25
+  DATAIN_B_26 DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31
+  DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37
+  DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43
+  DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49
+  DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55
+  DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61
+  DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4
+  GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13
+  GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21
+  GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29
+  GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37
+  GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45
+  GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53
+  GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61
+  GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6
+  GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14
+  GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22
+  GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30
+  GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38
+  GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46
+  GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54
+  GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62
+  GDL_B_63 LOG0_DBL_A LOG0_DBL_B NACT NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B
+  NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1
+  NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7
+  NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13
+  NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19
+  NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25
+  NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31
+  NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37
+  NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43
+  NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49
+  NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55
+  NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61
+  NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3
+  NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9
+  NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15
+  NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21
+  NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27
+  NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33
+  NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39
+  NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45
+  NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51
+  NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57
+  NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63
+  NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0]
+  RETA[1] RETB[0] RETB[1] RE_A RE_B VDDCA VDDCB VDDCE VDDPE VPW WE_A WE_B
+  WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256SGAR0_64_32_32_0_S: 159219 flat devices **
XARRAY0 ACTCLMP_A_1 ACTCLMP_B_1 CA_A[0] CA_A[1] CA_B[0] CA_B[1] BIT_A[0]_0
+  BIT_A[1]_0 BIT_A[2]_0 BIT_A[3]_0 BIT_A[0]_1 BIT_A[1]_1 BIT_A[2]_1
+  BIT_A[3]_1 BIT_A[0]_2 BIT_A[1]_2 BIT_A[2]_2 BIT_A[3]_2 BIT_A[0]_3
+  BIT_A[1]_3 BIT_A[2]_3 BIT_A[3]_3 BIT_A[0]_4 BIT_A[1]_4 BIT_A[2]_4
+  BIT_A[3]_4 BIT_A[0]_5 BIT_A[1]_5 BIT_A[2]_5 BIT_A[3]_5 BIT_A[0]_6
+  BIT_A[1]_6 BIT_A[2]_6 BIT_A[3]_6 BIT_A[0]_7 BIT_A[1]_7 BIT_A[2]_7
+  BIT_A[3]_7 BIT_A[0]_8 BIT_A[1]_8 BIT_A[2]_8 BIT_A[3]_8 BIT_A[0]_9
+  BIT_A[1]_9 BIT_A[2]_9 BIT_A[3]_9 BIT_A[0]_10 BIT_A[1]_10 BIT_A[2]_10
+  BIT_A[3]_10 BIT_A[0]_11 BIT_A[1]_11 BIT_A[2]_11 BIT_A[3]_11 BIT_A[0]_12
+  BIT_A[1]_12 BIT_A[2]_12 BIT_A[3]_12 BIT_A[0]_13 BIT_A[1]_13 BIT_A[2]_13
+  BIT_A[3]_13 BIT_A[0]_14 BIT_A[1]_14 BIT_A[2]_14 BIT_A[3]_14 BIT_A[0]_15
+  BIT_A[1]_15 BIT_A[2]_15 BIT_A[3]_15 BIT_A[0]_16 BIT_A[1]_16 BIT_A[2]_16
+  BIT_A[3]_16 BIT_A[0]_17 BIT_A[1]_17 BIT_A[2]_17 BIT_A[3]_17 BIT_A[0]_18
+  BIT_A[1]_18 BIT_A[2]_18 BIT_A[3]_18 BIT_A[0]_19 BIT_A[1]_19 BIT_A[2]_19
+  BIT_A[3]_19 BIT_A[0]_20 BIT_A[1]_20 BIT_A[2]_20 BIT_A[3]_20 BIT_A[0]_21
+  BIT_A[1]_21 BIT_A[2]_21 BIT_A[3]_21 BIT_A[0]_22 BIT_A[1]_22 BIT_A[2]_22
+  BIT_A[3]_22 BIT_A[0]_23 BIT_A[1]_23 BIT_A[2]_23 BIT_A[3]_23 BIT_A[0]_24
+  BIT_A[1]_24 BIT_A[2]_24 BIT_A[3]_24 BIT_A[0]_25 BIT_A[1]_25 BIT_A[2]_25
+  BIT_A[3]_25 BIT_A[0]_26 BIT_A[1]_26 BIT_A[2]_26 BIT_A[3]_26 BIT_A[0]_27
+  BIT_A[1]_27 BIT_A[2]_27 BIT_A[3]_27 BIT_A[0]_28 BIT_A[1]_28 BIT_A[2]_28
+  BIT_A[3]_28 BIT_A[0]_29 BIT_A[1]_29 BIT_A[2]_29 BIT_A[3]_29 BIT_A[0]_30
+  BIT_A[1]_30 BIT_A[2]_30 BIT_A[3]_30 BIT_A[0]_31 BIT_A[1]_31 BIT_A[2]_31
+  BIT_A[3]_31 BIT_A[3]_32 BIT_A[2]_32 BIT_A[1]_32 BIT_A[0]_32 BIT_A[3]_33
+  BIT_A[2]_33 BIT_A[1]_33 BIT_A[0]_33 BIT_A[3]_34 BIT_A[2]_34 BIT_A[1]_34
+  BIT_A[0]_34 BIT_A[3]_35 BIT_A[2]_35 BIT_A[1]_35 BIT_A[0]_35 BIT_A[3]_36
+  BIT_A[2]_36 BIT_A[1]_36 BIT_A[0]_36 BIT_A[3]_37 BIT_A[2]_37 BIT_A[1]_37
+  BIT_A[0]_37 BIT_A[3]_38 BIT_A[2]_38 BIT_A[1]_38 BIT_A[0]_38 BIT_A[3]_39
+  BIT_A[2]_39 BIT_A[1]_39 BIT_A[0]_39 BIT_A[3]_40 BIT_A[2]_40 BIT_A[1]_40
+  BIT_A[0]_40 BIT_A[3]_41 BIT_A[2]_41 BIT_A[1]_41 BIT_A[0]_41 BIT_A[3]_42
+  BIT_A[2]_42 BIT_A[1]_42 BIT_A[0]_42 BIT_A[3]_43 BIT_A[2]_43 BIT_A[1]_43
+  BIT_A[0]_43 BIT_A[3]_44 BIT_A[2]_44 BIT_A[1]_44 BIT_A[0]_44 BIT_A[3]_45
+  BIT_A[2]_45 BIT_A[1]_45 BIT_A[0]_45 BIT_A[3]_46 BIT_A[2]_46 BIT_A[1]_46
+  BIT_A[0]_46 BIT_A[3]_47 BIT_A[2]_47 BIT_A[1]_47 BIT_A[0]_47 BIT_A[3]_48
+  BIT_A[2]_48 BIT_A[1]_48 BIT_A[0]_48 BIT_A[3]_49 BIT_A[2]_49 BIT_A[1]_49
+  BIT_A[0]_49 BIT_A[3]_50 BIT_A[2]_50 BIT_A[1]_50 BIT_A[0]_50 BIT_A[3]_51
+  BIT_A[2]_51 BIT_A[1]_51 BIT_A[0]_51 BIT_A[3]_52 BIT_A[2]_52 BIT_A[1]_52
+  BIT_A[0]_52 BIT_A[3]_53 BIT_A[2]_53 BIT_A[1]_53 BIT_A[0]_53 BIT_A[3]_54
+  BIT_A[2]_54 BIT_A[1]_54 BIT_A[0]_54 BIT_A[3]_55 BIT_A[2]_55 BIT_A[1]_55
+  BIT_A[0]_55 BIT_A[3]_56 BIT_A[2]_56 BIT_A[1]_56 BIT_A[0]_56 BIT_A[3]_57
+  BIT_A[2]_57 BIT_A[1]_57 BIT_A[0]_57 BIT_A[3]_58 BIT_A[2]_58 BIT_A[1]_58
+  BIT_A[0]_58 BIT_A[3]_59 BIT_A[2]_59 BIT_A[1]_59 BIT_A[0]_59 BIT_A[3]_60
+  BIT_A[2]_60 BIT_A[1]_60 BIT_A[0]_60 BIT_A[3]_61 BIT_A[2]_61 BIT_A[1]_61
+  BIT_A[0]_61 BIT_A[3]_62 BIT_A[2]_62 BIT_A[1]_62 BIT_A[0]_62 BIT_A[3]_63
+  BIT_A[2]_63 BIT_A[1]_63 BIT_A[0]_63 BIT_B[0]_0 BIT_B[1]_0 BIT_B[2]_0
+  BIT_B[3]_0 BIT_B[0]_1 BIT_B[1]_1 BIT_B[2]_1 BIT_B[3]_1 BIT_B[0]_2
+  BIT_B[1]_2 BIT_B[2]_2 BIT_B[3]_2 BIT_B[0]_3 BIT_B[1]_3 BIT_B[2]_3
+  BIT_B[3]_3 BIT_B[0]_4 BIT_B[1]_4 BIT_B[2]_4 BIT_B[3]_4 BIT_B[0]_5
+  BIT_B[1]_5 BIT_B[2]_5 BIT_B[3]_5 BIT_B[0]_6 BIT_B[1]_6 BIT_B[2]_6
+  BIT_B[3]_6 BIT_B[0]_7 BIT_B[1]_7 BIT_B[2]_7 BIT_B[3]_7 BIT_B[0]_8
+  BIT_B[1]_8 BIT_B[2]_8 BIT_B[3]_8 BIT_B[0]_9 BIT_B[1]_9 BIT_B[2]_9
+  BIT_B[3]_9 BIT_B[0]_10 BIT_B[1]_10 BIT_B[2]_10 BIT_B[3]_10 BIT_B[0]_11
+  BIT_B[1]_11 BIT_B[2]_11 BIT_B[3]_11 BIT_B[0]_12 BIT_B[1]_12 BIT_B[2]_12
+  BIT_B[3]_12 BIT_B[0]_13 BIT_B[1]_13 BIT_B[2]_13 BIT_B[3]_13 BIT_B[0]_14
+  BIT_B[1]_14 BIT_B[2]_14 BIT_B[3]_14 BIT_B[0]_15 BIT_B[1]_15 BIT_B[2]_15
+  BIT_B[3]_15 BIT_B[0]_16 BIT_B[1]_16 BIT_B[2]_16 BIT_B[3]_16 BIT_B[0]_17
+  BIT_B[1]_17 BIT_B[2]_17 BIT_B[3]_17 BIT_B[0]_18 BIT_B[1]_18 BIT_B[2]_18
+  BIT_B[3]_18 BIT_B[0]_19 BIT_B[1]_19 BIT_B[2]_19 BIT_B[3]_19 BIT_B[0]_20
+  BIT_B[1]_20 BIT_B[2]_20 BIT_B[3]_20 BIT_B[0]_21 BIT_B[1]_21 BIT_B[2]_21
+  BIT_B[3]_21 BIT_B[0]_22 BIT_B[1]_22 BIT_B[2]_22 BIT_B[3]_22 BIT_B[0]_23
+  BIT_B[1]_23 BIT_B[2]_23 BIT_B[3]_23 BIT_B[0]_24 BIT_B[1]_24 BIT_B[2]_24
+  BIT_B[3]_24 BIT_B[0]_25 BIT_B[1]_25 BIT_B[2]_25 BIT_B[3]_25 BIT_B[0]_26
+  BIT_B[1]_26 BIT_B[2]_26 BIT_B[3]_26 BIT_B[0]_27 BIT_B[1]_27 BIT_B[2]_27
+  BIT_B[3]_27 BIT_B[0]_28 BIT_B[1]_28 BIT_B[2]_28 BIT_B[3]_28 BIT_B[0]_29
+  BIT_B[1]_29 BIT_B[2]_29 BIT_B[3]_29 BIT_B[0]_30 BIT_B[1]_30 BIT_B[2]_30
+  BIT_B[3]_30 BIT_B[0]_31 BIT_B[1]_31 BIT_B[2]_31 BIT_B[3]_31 BIT_B[3]_32
+  BIT_B[2]_32 BIT_B[1]_32 BIT_B[0]_32 BIT_B[3]_33 BIT_B[2]_33 BIT_B[1]_33
+  BIT_B[0]_33 BIT_B[3]_34 BIT_B[2]_34 BIT_B[1]_34 BIT_B[0]_34 BIT_B[3]_35
+  BIT_B[2]_35 BIT_B[1]_35 BIT_B[0]_35 BIT_B[3]_36 BIT_B[2]_36 BIT_B[1]_36
+  BIT_B[0]_36 BIT_B[3]_37 BIT_B[2]_37 BIT_B[1]_37 BIT_B[0]_37 BIT_B[3]_38
+  BIT_B[2]_38 BIT_B[1]_38 BIT_B[0]_38 BIT_B[3]_39 BIT_B[2]_39 BIT_B[1]_39
+  BIT_B[0]_39 BIT_B[3]_40 BIT_B[2]_40 BIT_B[1]_40 BIT_B[0]_40 BIT_B[3]_41
+  BIT_B[2]_41 BIT_B[1]_41 BIT_B[0]_41 BIT_B[3]_42 BIT_B[2]_42 BIT_B[1]_42
+  BIT_B[0]_42 BIT_B[3]_43 BIT_B[2]_43 BIT_B[1]_43 BIT_B[0]_43 BIT_B[3]_44
+  BIT_B[2]_44 BIT_B[1]_44 BIT_B[0]_44 BIT_B[3]_45 BIT_B[2]_45 BIT_B[1]_45
+  BIT_B[0]_45 BIT_B[3]_46 BIT_B[2]_46 BIT_B[1]_46 BIT_B[0]_46 BIT_B[3]_47
+  BIT_B[2]_47 BIT_B[1]_47 BIT_B[0]_47 BIT_B[3]_48 BIT_B[2]_48 BIT_B[1]_48
+  BIT_B[0]_48 BIT_B[3]_49 BIT_B[2]_49 BIT_B[1]_49 BIT_B[0]_49 BIT_B[3]_50
+  BIT_B[2]_50 BIT_B[1]_50 BIT_B[0]_50 BIT_B[3]_51 BIT_B[2]_51 BIT_B[1]_51
+  BIT_B[0]_51 BIT_B[3]_52 BIT_B[2]_52 BIT_B[1]_52 BIT_B[0]_52 BIT_B[3]_53
+  BIT_B[2]_53 BIT_B[1]_53 BIT_B[0]_53 BIT_B[3]_54 BIT_B[2]_54 BIT_B[1]_54
+  BIT_B[0]_54 BIT_B[3]_55 BIT_B[2]_55 BIT_B[1]_55 BIT_B[0]_55 BIT_B[3]_56
+  BIT_B[2]_56 BIT_B[1]_56 BIT_B[0]_56 BIT_B[3]_57 BIT_B[2]_57 BIT_B[1]_57
+  BIT_B[0]_57 BIT_B[3]_58 BIT_B[2]_58 BIT_B[1]_58 BIT_B[0]_58 BIT_B[3]_59
+  BIT_B[2]_59 BIT_B[1]_59 BIT_B[0]_59 BIT_B[3]_60 BIT_B[2]_60 BIT_B[1]_60
+  BIT_B[0]_60 BIT_B[3]_61 BIT_B[2]_61 BIT_B[1]_61 BIT_B[0]_61 BIT_B[3]_62
+  BIT_B[2]_62 BIT_B[1]_62 BIT_B[0]_62 BIT_B[3]_63 BIT_B[2]_63 BIT_B[1]_63
+  BIT_B[0]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_B_0 DATAIN_A_0 DATAIN_B_1
+  DATAIN_A_1 DATAIN_B_2 DATAIN_A_2 DATAIN_B_3 DATAIN_A_3 DATAIN_B_4
+  DATAIN_A_4 DATAIN_B_5 DATAIN_A_5 DATAIN_B_6 DATAIN_A_6 DATAIN_B_7
+  DATAIN_A_7 DATAIN_B_8 DATAIN_A_8 DATAIN_B_9 DATAIN_A_9 DATAIN_B_10
+  DATAIN_A_10 DATAIN_B_11 DATAIN_A_11 DATAIN_B_12 DATAIN_A_12 DATAIN_B_13
+  DATAIN_A_13 DATAIN_B_14 DATAIN_A_14 DATAIN_B_15 DATAIN_A_15 DATAIN_B_16
+  DATAIN_A_16 DATAIN_B_17 DATAIN_A_17 DATAIN_B_18 DATAIN_A_18 DATAIN_B_19
+  DATAIN_A_19 DATAIN_B_20 DATAIN_A_20 DATAIN_B_21 DATAIN_A_21 DATAIN_B_22
+  DATAIN_A_22 DATAIN_B_23 DATAIN_A_23 DATAIN_B_24 DATAIN_A_24 DATAIN_B_25
+  DATAIN_A_25 DATAIN_B_26 DATAIN_A_26 DATAIN_B_27 DATAIN_A_27 DATAIN_B_28
+  DATAIN_A_28 DATAIN_B_29 DATAIN_A_29 DATAIN_B_30 DATAIN_A_30 DATAIN_B_31
+  DATAIN_A_31 DATAIN_A_32 DATAIN_B_32 DATAIN_A_33 DATAIN_B_33 DATAIN_A_34
+  DATAIN_B_34 DATAIN_A_35 DATAIN_B_35 DATAIN_A_36 DATAIN_B_36 DATAIN_A_37
+  DATAIN_B_37 DATAIN_A_38 DATAIN_B_38 DATAIN_A_39 DATAIN_B_39 DATAIN_A_40
+  DATAIN_B_40 DATAIN_A_41 DATAIN_B_41 DATAIN_A_42 DATAIN_B_42 DATAIN_A_43
+  DATAIN_B_43 DATAIN_A_44 DATAIN_B_44 DATAIN_A_45 DATAIN_B_45 DATAIN_A_46
+  DATAIN_B_46 DATAIN_A_47 DATAIN_B_47 DATAIN_A_48 DATAIN_B_48 DATAIN_A_49
+  DATAIN_B_49 DATAIN_A_50 DATAIN_B_50 DATAIN_A_51 DATAIN_B_51 DATAIN_A_52
+  DATAIN_B_52 DATAIN_A_53 DATAIN_B_53 DATAIN_A_54 DATAIN_B_54 DATAIN_A_55
+  DATAIN_B_55 DATAIN_A_56 DATAIN_B_56 DATAIN_A_57 DATAIN_B_57 DATAIN_A_58
+  DATAIN_B_58 DATAIN_A_59 DATAIN_B_59 DATAIN_A_60 DATAIN_B_60 DATAIN_A_61
+  DATAIN_B_61 DATAIN_A_62 DATAIN_B_62 DATAIN_A_63 DATAIN_B_63 DBL_A DBL_B
+  GDL_B_0 GDL_A_0 GDL_B_1 GDL_A_1 GDL_B_2 GDL_A_2 GDL_B_3 GDL_A_3 GDL_B_4
+  GDL_A_4 GDL_B_5 GDL_A_5 GDL_B_6 GDL_A_6 GDL_B_7 GDL_A_7 GDL_B_8 GDL_A_8
+  GDL_B_9 GDL_A_9 GDL_B_10 GDL_A_10 GDL_B_11 GDL_A_11 GDL_B_12 GDL_A_12
+  GDL_B_13 GDL_A_13 GDL_B_14 GDL_A_14 GDL_B_15 GDL_A_15 GDL_B_16 GDL_A_16
+  GDL_B_17 GDL_A_17 GDL_B_18 GDL_A_18 GDL_B_19 GDL_A_19 GDL_B_20 GDL_A_20
+  GDL_B_21 GDL_A_21 GDL_B_22 GDL_A_22 GDL_B_23 GDL_A_23 GDL_B_24 GDL_A_24
+  GDL_B_25 GDL_A_25 GDL_B_26 GDL_A_26 GDL_B_27 GDL_A_27 GDL_B_28 GDL_A_28
+  GDL_B_29 GDL_A_29 GDL_B_30 GDL_A_30 GDL_B_31 GDL_A_31 GDL_A_32 GDL_B_32
+  GDL_A_33 GDL_B_33 GDL_A_34 GDL_B_34 GDL_A_35 GDL_B_35 GDL_A_36 GDL_B_36
+  GDL_A_37 GDL_B_37 GDL_A_38 GDL_B_38 GDL_A_39 GDL_B_39 GDL_A_40 GDL_B_40
+  GDL_A_41 GDL_B_41 GDL_A_42 GDL_B_42 GDL_A_43 GDL_B_43 GDL_A_44 GDL_B_44
+  GDL_A_45 GDL_B_45 GDL_A_46 GDL_B_46 GDL_A_47 GDL_B_47 GDL_A_48 GDL_B_48
+  GDL_A_49 GDL_B_49 GDL_A_50 GDL_B_50 GDL_A_51 GDL_B_51 GDL_A_52 GDL_B_52
+  GDL_A_53 GDL_B_53 GDL_A_54 GDL_B_54 GDL_A_55 GDL_B_55 GDL_A_56 GDL_B_56
+  GDL_A_57 GDL_B_57 GDL_A_58 GDL_B_58 GDL_A_59 GDL_B_59 GDL_A_60 GDL_B_60
+  GDL_A_61 GDL_B_61 GDL_A_62 GDL_B_62 GDL_A_63 GDL_B_63 LOG0_DBL_A LOG0_DBL_B
+  NACT NBIT_A[0]_0 NBIT_A[1]_0 NBIT_A[2]_0 NBIT_A[3]_0 NBIT_A[0]_1
+  NBIT_A[1]_1 NBIT_A[2]_1 NBIT_A[3]_1 NBIT_A[0]_2 NBIT_A[1]_2 NBIT_A[2]_2
+  NBIT_A[3]_2 NBIT_A[0]_3 NBIT_A[1]_3 NBIT_A[2]_3 NBIT_A[3]_3 NBIT_A[0]_4
+  NBIT_A[1]_4 NBIT_A[2]_4 NBIT_A[3]_4 NBIT_A[0]_5 NBIT_A[1]_5 NBIT_A[2]_5
+  NBIT_A[3]_5 NBIT_A[0]_6 NBIT_A[1]_6 NBIT_A[2]_6 NBIT_A[3]_6 NBIT_A[0]_7
+  NBIT_A[1]_7 NBIT_A[2]_7 NBIT_A[3]_7 NBIT_A[0]_8 NBIT_A[1]_8 NBIT_A[2]_8
+  NBIT_A[3]_8 NBIT_A[0]_9 NBIT_A[1]_9 NBIT_A[2]_9 NBIT_A[3]_9 NBIT_A[0]_10
+  NBIT_A[1]_10 NBIT_A[2]_10 NBIT_A[3]_10 NBIT_A[0]_11 NBIT_A[1]_11
+  NBIT_A[2]_11 NBIT_A[3]_11 NBIT_A[0]_12 NBIT_A[1]_12 NBIT_A[2]_12
+  NBIT_A[3]_12 NBIT_A[0]_13 NBIT_A[1]_13 NBIT_A[2]_13 NBIT_A[3]_13
+  NBIT_A[0]_14 NBIT_A[1]_14 NBIT_A[2]_14 NBIT_A[3]_14 NBIT_A[0]_15
+  NBIT_A[1]_15 NBIT_A[2]_15 NBIT_A[3]_15 NBIT_A[0]_16 NBIT_A[1]_16
+  NBIT_A[2]_16 NBIT_A[3]_16 NBIT_A[0]_17 NBIT_A[1]_17 NBIT_A[2]_17
+  NBIT_A[3]_17 NBIT_A[0]_18 NBIT_A[1]_18 NBIT_A[2]_18 NBIT_A[3]_18
+  NBIT_A[0]_19 NBIT_A[1]_19 NBIT_A[2]_19 NBIT_A[3]_19 NBIT_A[0]_20
+  NBIT_A[1]_20 NBIT_A[2]_20 NBIT_A[3]_20 NBIT_A[0]_21 NBIT_A[1]_21
+  NBIT_A[2]_21 NBIT_A[3]_21 NBIT_A[0]_22 NBIT_A[1]_22 NBIT_A[2]_22
+  NBIT_A[3]_22 NBIT_A[0]_23 NBIT_A[1]_23 NBIT_A[2]_23 NBIT_A[3]_23
+  NBIT_A[0]_24 NBIT_A[1]_24 NBIT_A[2]_24 NBIT_A[3]_24 NBIT_A[0]_25
+  NBIT_A[1]_25 NBIT_A[2]_25 NBIT_A[3]_25 NBIT_A[0]_26 NBIT_A[1]_26
+  NBIT_A[2]_26 NBIT_A[3]_26 NBIT_A[0]_27 NBIT_A[1]_27 NBIT_A[2]_27
+  NBIT_A[3]_27 NBIT_A[0]_28 NBIT_A[1]_28 NBIT_A[2]_28 NBIT_A[3]_28
+  NBIT_A[0]_29 NBIT_A[1]_29 NBIT_A[2]_29 NBIT_A[3]_29 NBIT_A[0]_30
+  NBIT_A[1]_30 NBIT_A[2]_30 NBIT_A[3]_30 NBIT_A[0]_31 NBIT_A[1]_31
+  NBIT_A[2]_31 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[2]_32 NBIT_A[1]_32
+  NBIT_A[0]_32 NBIT_A[3]_33 NBIT_A[2]_33 NBIT_A[1]_33 NBIT_A[0]_33
+  NBIT_A[3]_34 NBIT_A[2]_34 NBIT_A[1]_34 NBIT_A[0]_34 NBIT_A[3]_35
+  NBIT_A[2]_35 NBIT_A[1]_35 NBIT_A[0]_35 NBIT_A[3]_36 NBIT_A[2]_36
+  NBIT_A[1]_36 NBIT_A[0]_36 NBIT_A[3]_37 NBIT_A[2]_37 NBIT_A[1]_37
+  NBIT_A[0]_37 NBIT_A[3]_38 NBIT_A[2]_38 NBIT_A[1]_38 NBIT_A[0]_38
+  NBIT_A[3]_39 NBIT_A[2]_39 NBIT_A[1]_39 NBIT_A[0]_39 NBIT_A[3]_40
+  NBIT_A[2]_40 NBIT_A[1]_40 NBIT_A[0]_40 NBIT_A[3]_41 NBIT_A[2]_41
+  NBIT_A[1]_41 NBIT_A[0]_41 NBIT_A[3]_42 NBIT_A[2]_42 NBIT_A[1]_42
+  NBIT_A[0]_42 NBIT_A[3]_43 NBIT_A[2]_43 NBIT_A[1]_43 NBIT_A[0]_43
+  NBIT_A[3]_44 NBIT_A[2]_44 NBIT_A[1]_44 NBIT_A[0]_44 NBIT_A[3]_45
+  NBIT_A[2]_45 NBIT_A[1]_45 NBIT_A[0]_45 NBIT_A[3]_46 NBIT_A[2]_46
+  NBIT_A[1]_46 NBIT_A[0]_46 NBIT_A[3]_47 NBIT_A[2]_47 NBIT_A[1]_47
+  NBIT_A[0]_47 NBIT_A[3]_48 NBIT_A[2]_48 NBIT_A[1]_48 NBIT_A[0]_48
+  NBIT_A[3]_49 NBIT_A[2]_49 NBIT_A[1]_49 NBIT_A[0]_49 NBIT_A[3]_50
+  NBIT_A[2]_50 NBIT_A[1]_50 NBIT_A[0]_50 NBIT_A[3]_51 NBIT_A[2]_51
+  NBIT_A[1]_51 NBIT_A[0]_51 NBIT_A[3]_52 NBIT_A[2]_52 NBIT_A[1]_52
+  NBIT_A[0]_52 NBIT_A[3]_53 NBIT_A[2]_53 NBIT_A[1]_53 NBIT_A[0]_53
+  NBIT_A[3]_54 NBIT_A[2]_54 NBIT_A[1]_54 NBIT_A[0]_54 NBIT_A[3]_55
+  NBIT_A[2]_55 NBIT_A[1]_55 NBIT_A[0]_55 NBIT_A[3]_56 NBIT_A[2]_56
+  NBIT_A[1]_56 NBIT_A[0]_56 NBIT_A[3]_57 NBIT_A[2]_57 NBIT_A[1]_57
+  NBIT_A[0]_57 NBIT_A[3]_58 NBIT_A[2]_58 NBIT_A[1]_58 NBIT_A[0]_58
+  NBIT_A[3]_59 NBIT_A[2]_59 NBIT_A[1]_59 NBIT_A[0]_59 NBIT_A[3]_60
+  NBIT_A[2]_60 NBIT_A[1]_60 NBIT_A[0]_60 NBIT_A[3]_61 NBIT_A[2]_61
+  NBIT_A[1]_61 NBIT_A[0]_61 NBIT_A[3]_62 NBIT_A[2]_62 NBIT_A[1]_62
+  NBIT_A[0]_62 NBIT_A[3]_63 NBIT_A[2]_63 NBIT_A[1]_63 NBIT_A[0]_63
+  NBIT_B[0]_0 NBIT_B[1]_0 NBIT_B[2]_0 NBIT_B[3]_0 NBIT_B[0]_1 NBIT_B[1]_1
+  NBIT_B[2]_1 NBIT_B[3]_1 NBIT_B[0]_2 NBIT_B[1]_2 NBIT_B[2]_2 NBIT_B[3]_2
+  NBIT_B[0]_3 NBIT_B[1]_3 NBIT_B[2]_3 NBIT_B[3]_3 NBIT_B[0]_4 NBIT_B[1]_4
+  NBIT_B[2]_4 NBIT_B[3]_4 NBIT_B[0]_5 NBIT_B[1]_5 NBIT_B[2]_5 NBIT_B[3]_5
+  NBIT_B[0]_6 NBIT_B[1]_6 NBIT_B[2]_6 NBIT_B[3]_6 NBIT_B[0]_7 NBIT_B[1]_7
+  NBIT_B[2]_7 NBIT_B[3]_7 NBIT_B[0]_8 NBIT_B[1]_8 NBIT_B[2]_8 NBIT_B[3]_8
+  NBIT_B[0]_9 NBIT_B[1]_9 NBIT_B[2]_9 NBIT_B[3]_9 NBIT_B[0]_10 NBIT_B[1]_10
+  NBIT_B[2]_10 NBIT_B[3]_10 NBIT_B[0]_11 NBIT_B[1]_11 NBIT_B[2]_11
+  NBIT_B[3]_11 NBIT_B[0]_12 NBIT_B[1]_12 NBIT_B[2]_12 NBIT_B[3]_12
+  NBIT_B[0]_13 NBIT_B[1]_13 NBIT_B[2]_13 NBIT_B[3]_13 NBIT_B[0]_14
+  NBIT_B[1]_14 NBIT_B[2]_14 NBIT_B[3]_14 NBIT_B[0]_15 NBIT_B[1]_15
+  NBIT_B[2]_15 NBIT_B[3]_15 NBIT_B[0]_16 NBIT_B[1]_16 NBIT_B[2]_16
+  NBIT_B[3]_16 NBIT_B[0]_17 NBIT_B[1]_17 NBIT_B[2]_17 NBIT_B[3]_17
+  NBIT_B[0]_18 NBIT_B[1]_18 NBIT_B[2]_18 NBIT_B[3]_18 NBIT_B[0]_19
+  NBIT_B[1]_19 NBIT_B[2]_19 NBIT_B[3]_19 NBIT_B[0]_20 NBIT_B[1]_20
+  NBIT_B[2]_20 NBIT_B[3]_20 NBIT_B[0]_21 NBIT_B[1]_21 NBIT_B[2]_21
+  NBIT_B[3]_21 NBIT_B[0]_22 NBIT_B[1]_22 NBIT_B[2]_22 NBIT_B[3]_22
+  NBIT_B[0]_23 NBIT_B[1]_23 NBIT_B[2]_23 NBIT_B[3]_23 NBIT_B[0]_24
+  NBIT_B[1]_24 NBIT_B[2]_24 NBIT_B[3]_24 NBIT_B[0]_25 NBIT_B[1]_25
+  NBIT_B[2]_25 NBIT_B[3]_25 NBIT_B[0]_26 NBIT_B[1]_26 NBIT_B[2]_26
+  NBIT_B[3]_26 NBIT_B[0]_27 NBIT_B[1]_27 NBIT_B[2]_27 NBIT_B[3]_27
+  NBIT_B[0]_28 NBIT_B[1]_28 NBIT_B[2]_28 NBIT_B[3]_28 NBIT_B[0]_29
+  NBIT_B[1]_29 NBIT_B[2]_29 NBIT_B[3]_29 NBIT_B[0]_30 NBIT_B[1]_30
+  NBIT_B[2]_30 NBIT_B[3]_30 NBIT_B[0]_31 NBIT_B[1]_31 NBIT_B[2]_31
+  NBIT_B[3]_31 NBIT_B[3]_32 NBIT_B[2]_32 NBIT_B[1]_32 NBIT_B[0]_32
+  NBIT_B[3]_33 NBIT_B[2]_33 NBIT_B[1]_33 NBIT_B[0]_33 NBIT_B[3]_34
+  NBIT_B[2]_34 NBIT_B[1]_34 NBIT_B[0]_34 NBIT_B[3]_35 NBIT_B[2]_35
+  NBIT_B[1]_35 NBIT_B[0]_35 NBIT_B[3]_36 NBIT_B[2]_36 NBIT_B[1]_36
+  NBIT_B[0]_36 NBIT_B[3]_37 NBIT_B[2]_37 NBIT_B[1]_37 NBIT_B[0]_37
+  NBIT_B[3]_38 NBIT_B[2]_38 NBIT_B[1]_38 NBIT_B[0]_38 NBIT_B[3]_39
+  NBIT_B[2]_39 NBIT_B[1]_39 NBIT_B[0]_39 NBIT_B[3]_40 NBIT_B[2]_40
+  NBIT_B[1]_40 NBIT_B[0]_40 NBIT_B[3]_41 NBIT_B[2]_41 NBIT_B[1]_41
+  NBIT_B[0]_41 NBIT_B[3]_42 NBIT_B[2]_42 NBIT_B[1]_42 NBIT_B[0]_42
+  NBIT_B[3]_43 NBIT_B[2]_43 NBIT_B[1]_43 NBIT_B[0]_43 NBIT_B[3]_44
+  NBIT_B[2]_44 NBIT_B[1]_44 NBIT_B[0]_44 NBIT_B[3]_45 NBIT_B[2]_45
+  NBIT_B[1]_45 NBIT_B[0]_45 NBIT_B[3]_46 NBIT_B[2]_46 NBIT_B[1]_46
+  NBIT_B[0]_46 NBIT_B[3]_47 NBIT_B[2]_47 NBIT_B[1]_47 NBIT_B[0]_47
+  NBIT_B[3]_48 NBIT_B[2]_48 NBIT_B[1]_48 NBIT_B[0]_48 NBIT_B[3]_49
+  NBIT_B[2]_49 NBIT_B[1]_49 NBIT_B[0]_49 NBIT_B[3]_50 NBIT_B[2]_50
+  NBIT_B[1]_50 NBIT_B[0]_50 NBIT_B[3]_51 NBIT_B[2]_51 NBIT_B[1]_51
+  NBIT_B[0]_51 NBIT_B[3]_52 NBIT_B[2]_52 NBIT_B[1]_52 NBIT_B[0]_52
+  NBIT_B[3]_53 NBIT_B[2]_53 NBIT_B[1]_53 NBIT_B[0]_53 NBIT_B[3]_54
+  NBIT_B[2]_54 NBIT_B[1]_54 NBIT_B[0]_54 NBIT_B[3]_55 NBIT_B[2]_55
+  NBIT_B[1]_55 NBIT_B[0]_55 NBIT_B[3]_56 NBIT_B[2]_56 NBIT_B[1]_56
+  NBIT_B[0]_56 NBIT_B[3]_57 NBIT_B[2]_57 NBIT_B[1]_57 NBIT_B[0]_57
+  NBIT_B[3]_58 NBIT_B[2]_58 NBIT_B[1]_58 NBIT_B[0]_58 NBIT_B[3]_59
+  NBIT_B[2]_59 NBIT_B[1]_59 NBIT_B[0]_59 NBIT_B[3]_60 NBIT_B[2]_60
+  NBIT_B[1]_60 NBIT_B[0]_60 NBIT_B[3]_61 NBIT_B[2]_61 NBIT_B[1]_61
+  NBIT_B[0]_61 NBIT_B[3]_62 NBIT_B[2]_62 NBIT_B[1]_62 NBIT_B[0]_62
+  NBIT_B[3]_63 NBIT_B[2]_63 NBIT_B[1]_63 NBIT_B[0]_63 NDFTRAMBYP_A
+  NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_B_0
+  NWGSEL_A_0 NWGSEL_B_1 NWGSEL_A_1 NWGSEL_B_2 NWGSEL_A_2 NWGSEL_B_3
+  NWGSEL_A_3 NWGSEL_B_4 NWGSEL_A_4 NWGSEL_B_5 NWGSEL_A_5 NWGSEL_B_6
+  NWGSEL_A_6 NWGSEL_B_7 NWGSEL_A_7 NWGSEL_B_8 NWGSEL_A_8 NWGSEL_B_9
+  NWGSEL_A_9 NWGSEL_B_10 NWGSEL_A_10 NWGSEL_B_11 NWGSEL_A_11 NWGSEL_B_12
+  NWGSEL_A_12 NWGSEL_B_13 NWGSEL_A_13 NWGSEL_B_14 NWGSEL_A_14 NWGSEL_B_15
+  NWGSEL_A_15 NWGSEL_B_16 NWGSEL_A_16 NWGSEL_B_17 NWGSEL_A_17 NWGSEL_B_18
+  NWGSEL_A_18 NWGSEL_B_19 NWGSEL_A_19 NWGSEL_B_20 NWGSEL_A_20 NWGSEL_B_21
+  NWGSEL_A_21 NWGSEL_B_22 NWGSEL_A_22 NWGSEL_B_23 NWGSEL_A_23 NWGSEL_B_24
+  NWGSEL_A_24 NWGSEL_B_25 NWGSEL_A_25 NWGSEL_B_26 NWGSEL_A_26 NWGSEL_B_27
+  NWGSEL_A_27 NWGSEL_B_28 NWGSEL_A_28 NWGSEL_B_29 NWGSEL_A_29 NWGSEL_B_30
+  NWGSEL_A_30 NWGSEL_B_31 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_B_32 NWGSEL_A_33
+  NWGSEL_B_33 NWGSEL_A_34 NWGSEL_B_34 NWGSEL_A_35 NWGSEL_B_35 NWGSEL_A_36
+  NWGSEL_B_36 NWGSEL_A_37 NWGSEL_B_37 NWGSEL_A_38 NWGSEL_B_38 NWGSEL_A_39
+  NWGSEL_B_39 NWGSEL_A_40 NWGSEL_B_40 NWGSEL_A_41 NWGSEL_B_41 NWGSEL_A_42
+  NWGSEL_B_42 NWGSEL_A_43 NWGSEL_B_43 NWGSEL_A_44 NWGSEL_B_44 NWGSEL_A_45
+  NWGSEL_B_45 NWGSEL_A_46 NWGSEL_B_46 NWGSEL_A_47 NWGSEL_B_47 NWGSEL_A_48
+  NWGSEL_B_48 NWGSEL_A_49 NWGSEL_B_49 NWGSEL_A_50 NWGSEL_B_50 NWGSEL_A_51
+  NWGSEL_B_51 NWGSEL_A_52 NWGSEL_B_52 NWGSEL_A_53 NWGSEL_B_53 NWGSEL_A_54
+  NWGSEL_B_54 NWGSEL_A_55 NWGSEL_B_55 NWGSEL_A_56 NWGSEL_B_56 NWGSEL_A_57
+  NWGSEL_B_57 NWGSEL_A_58 NWGSEL_B_58 NWGSEL_A_59 NWGSEL_B_59 NWGSEL_A_60
+  NWGSEL_B_60 NWGSEL_A_61 NWGSEL_B_61 NWGSEL_A_62 NWGSEL_B_62 NWGSEL_A_63
+  NWGSEL_B_63 NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2]
+  NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7]
+  NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4]
+  NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1]
+  NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6]
+  NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3]
+  NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0]
+  NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1]
+  NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RET_SHR_DEC1A[0]
+  RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A RE_B VDDCA VDDCA
+  VDDCB VDDCB VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE VDDPE
+  VDDPE VDDPE VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW
+  VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW VPW WE_A WE_B WRA_MA WRB_MA
+  WTE_A WTE_B SRAMdpw64d256ARRAY_64_32_32
XARRAYTCAP ACTCLMP_A_1 ACTCLMP_B_1 CA_A[0] CA_A[1] CA_B[0] CA_B[1] BIT_A[0]_0
+  BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3 BIT_A[0]_4 BIT_A[0]_5 BIT_A[0]_6
+  BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9 BIT_A[0]_10 BIT_A[0]_11 BIT_A[0]_12
+  BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15 BIT_A[0]_16 BIT_A[0]_17 BIT_A[0]_18
+  BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21 BIT_A[0]_22 BIT_A[0]_23 BIT_A[0]_24
+  BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27 BIT_A[0]_28 BIT_A[0]_29 BIT_A[0]_30
+  BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34 BIT_A[0]_35 BIT_A[0]_36
+  BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40 BIT_A[0]_41 BIT_A[0]_42
+  BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46 BIT_A[0]_47 BIT_A[0]_48
+  BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52 BIT_A[0]_53 BIT_A[0]_54
+  BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58 BIT_A[0]_59 BIT_A[0]_60
+  BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_0 BIT_A[1]_1 BIT_A[1]_2
+  BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6 BIT_A[1]_7 BIT_A[1]_8
+  BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12 BIT_A[1]_13 BIT_A[1]_14
+  BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18 BIT_A[1]_19 BIT_A[1]_20
+  BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24 BIT_A[1]_25 BIT_A[1]_26
+  BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30 BIT_A[1]_31 BIT_A[1]_32
+  BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35 BIT_A[1]_36 BIT_A[1]_37 BIT_A[1]_38
+  BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41 BIT_A[1]_42 BIT_A[1]_43 BIT_A[1]_44
+  BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47 BIT_A[1]_48 BIT_A[1]_49 BIT_A[1]_50
+  BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53 BIT_A[1]_54 BIT_A[1]_55 BIT_A[1]_56
+  BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59 BIT_A[1]_60 BIT_A[1]_61 BIT_A[1]_62
+  BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2 BIT_A[2]_3 BIT_A[2]_4
+  BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8 BIT_A[2]_9 BIT_A[2]_10
+  BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14 BIT_A[2]_15 BIT_A[2]_16
+  BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20 BIT_A[2]_21 BIT_A[2]_22
+  BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26 BIT_A[2]_27 BIT_A[2]_28
+  BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31 BIT_A[2]_32 BIT_A[2]_33 BIT_A[2]_34
+  BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38 BIT_A[2]_39 BIT_A[2]_40
+  BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44 BIT_A[2]_45 BIT_A[2]_46
+  BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50 BIT_A[2]_51 BIT_A[2]_52
+  BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56 BIT_A[2]_57 BIT_A[2]_58
+  BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62 BIT_A[2]_63 BIT_A[3]_0
+  BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3 BIT_A[3]_4 BIT_A[3]_5 BIT_A[3]_6
+  BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9 BIT_A[3]_10 BIT_A[3]_11 BIT_A[3]_12
+  BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15 BIT_A[3]_16 BIT_A[3]_17 BIT_A[3]_18
+  BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21 BIT_A[3]_22 BIT_A[3]_23 BIT_A[3]_24
+  BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27 BIT_A[3]_28 BIT_A[3]_29 BIT_A[3]_30
+  BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34 BIT_A[3]_35 BIT_A[3]_36
+  BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40 BIT_A[3]_41 BIT_A[3]_42
+  BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46 BIT_A[3]_47 BIT_A[3]_48
+  BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52 BIT_A[3]_53 BIT_A[3]_54
+  BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58 BIT_A[3]_59 BIT_A[3]_60
+  BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_0 BIT_B[0]_1 BIT_B[0]_2
+  BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6 BIT_B[0]_7 BIT_B[0]_8
+  BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12 BIT_B[0]_13 BIT_B[0]_14
+  BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18 BIT_B[0]_19 BIT_B[0]_20
+  BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24 BIT_B[0]_25 BIT_B[0]_26
+  BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30 BIT_B[0]_31 BIT_B[0]_32
+  BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35 BIT_B[0]_36 BIT_B[0]_37 BIT_B[0]_38
+  BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41 BIT_B[0]_42 BIT_B[0]_43 BIT_B[0]_44
+  BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47 BIT_B[0]_48 BIT_B[0]_49 BIT_B[0]_50
+  BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53 BIT_B[0]_54 BIT_B[0]_55 BIT_B[0]_56
+  BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59 BIT_B[0]_60 BIT_B[0]_61 BIT_B[0]_62
+  BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2 BIT_B[1]_3 BIT_B[1]_4
+  BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8 BIT_B[1]_9 BIT_B[1]_10
+  BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14 BIT_B[1]_15 BIT_B[1]_16
+  BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20 BIT_B[1]_21 BIT_B[1]_22
+  BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26 BIT_B[1]_27 BIT_B[1]_28
+  BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31 BIT_B[1]_32 BIT_B[1]_33 BIT_B[1]_34
+  BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38 BIT_B[1]_39 BIT_B[1]_40
+  BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44 BIT_B[1]_45 BIT_B[1]_46
+  BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50 BIT_B[1]_51 BIT_B[1]_52
+  BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56 BIT_B[1]_57 BIT_B[1]_58
+  BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62 BIT_B[1]_63 BIT_B[2]_0
+  BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3 BIT_B[2]_4 BIT_B[2]_5 BIT_B[2]_6
+  BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9 BIT_B[2]_10 BIT_B[2]_11 BIT_B[2]_12
+  BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15 BIT_B[2]_16 BIT_B[2]_17 BIT_B[2]_18
+  BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21 BIT_B[2]_22 BIT_B[2]_23 BIT_B[2]_24
+  BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27 BIT_B[2]_28 BIT_B[2]_29 BIT_B[2]_30
+  BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34 BIT_B[2]_35 BIT_B[2]_36
+  BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40 BIT_B[2]_41 BIT_B[2]_42
+  BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46 BIT_B[2]_47 BIT_B[2]_48
+  BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52 BIT_B[2]_53 BIT_B[2]_54
+  BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58 BIT_B[2]_59 BIT_B[2]_60
+  BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_0 BIT_B[3]_1 BIT_B[3]_2
+  BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6 BIT_B[3]_7 BIT_B[3]_8
+  BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12 BIT_B[3]_13 BIT_B[3]_14
+  BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18 BIT_B[3]_19 BIT_B[3]_20
+  BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24 BIT_B[3]_25 BIT_B[3]_26
+  BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30 BIT_B[3]_31 BIT_B[3]_32
+  BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35 BIT_B[3]_36 BIT_B[3]_37 BIT_B[3]_38
+  BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41 BIT_B[3]_42 BIT_B[3]_43 BIT_B[3]_44
+  BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47 BIT_B[3]_48 BIT_B[3]_49 BIT_B[3]_50
+  BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53 BIT_B[3]_54 BIT_B[3]_55 BIT_B[3]_56
+  BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59 BIT_B[3]_60 BIT_B[3]_61 BIT_B[3]_62
+  BIT_B[3]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1 DATAIN_A_2
+  DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7 DATAIN_A_8
+  DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13 DATAIN_A_14
+  DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19 DATAIN_A_20
+  DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25 DATAIN_A_26
+  DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31 DATAIN_A_32
+  DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38
+  DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44
+  DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50
+  DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56
+  DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62
+  DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3 DATAIN_B_4
+  DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9 DATAIN_B_10
+  DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15 DATAIN_B_16
+  DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21 DATAIN_B_22
+  DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27 DATAIN_B_28
+  DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34
+  DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40
+  DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46
+  DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52
+  DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58
+  DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B
+  GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8
+  GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16
+  GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24
+  GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32
+  GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40
+  GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48
+  GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56
+  GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0
+  GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9
+  GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17
+  GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25
+  GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33
+  GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41
+  GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49
+  GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57
+  GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 LOG0_DBL_A LOG0_DBL_B
+  NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2 NBIT_A[0]_3 NBIT_A[0]_4
+  NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8 NBIT_A[0]_9 NBIT_A[0]_10
+  NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13 NBIT_A[0]_14 NBIT_A[0]_15
+  NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18 NBIT_A[0]_19 NBIT_A[0]_20
+  NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23 NBIT_A[0]_24 NBIT_A[0]_25
+  NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28 NBIT_A[0]_29 NBIT_A[0]_30
+  NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33 NBIT_A[0]_34 NBIT_A[0]_35
+  NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38 NBIT_A[0]_39 NBIT_A[0]_40
+  NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43 NBIT_A[0]_44 NBIT_A[0]_45
+  NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48 NBIT_A[0]_49 NBIT_A[0]_50
+  NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53 NBIT_A[0]_54 NBIT_A[0]_55
+  NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58 NBIT_A[0]_59 NBIT_A[0]_60
+  NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63 NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2
+  NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5 NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8
+  NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11 NBIT_A[1]_12 NBIT_A[1]_13
+  NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16 NBIT_A[1]_17 NBIT_A[1]_18
+  NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21 NBIT_A[1]_22 NBIT_A[1]_23
+  NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26 NBIT_A[1]_27 NBIT_A[1]_28
+  NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31 NBIT_A[1]_32 NBIT_A[1]_33
+  NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36 NBIT_A[1]_37 NBIT_A[1]_38
+  NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41 NBIT_A[1]_42 NBIT_A[1]_43
+  NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46 NBIT_A[1]_47 NBIT_A[1]_48
+  NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51 NBIT_A[1]_52 NBIT_A[1]_53
+  NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56 NBIT_A[1]_57 NBIT_A[1]_58
+  NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61 NBIT_A[1]_62 NBIT_A[1]_63
+  NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3 NBIT_A[2]_4 NBIT_A[2]_5
+  NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9 NBIT_A[2]_10 NBIT_A[2]_11
+  NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14 NBIT_A[2]_15 NBIT_A[2]_16
+  NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19 NBIT_A[2]_20 NBIT_A[2]_21
+  NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24 NBIT_A[2]_25 NBIT_A[2]_26
+  NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29 NBIT_A[2]_30 NBIT_A[2]_31
+  NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34 NBIT_A[2]_35 NBIT_A[2]_36
+  NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39 NBIT_A[2]_40 NBIT_A[2]_41
+  NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44 NBIT_A[2]_45 NBIT_A[2]_46
+  NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49 NBIT_A[2]_50 NBIT_A[2]_51
+  NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54 NBIT_A[2]_55 NBIT_A[2]_56
+  NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59 NBIT_A[2]_60 NBIT_A[2]_61
+  NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1 NBIT_A[3]_2 NBIT_A[3]_3
+  NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7 NBIT_A[3]_8 NBIT_A[3]_9
+  NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13 NBIT_A[3]_14
+  NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18 NBIT_A[3]_19
+  NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23 NBIT_A[3]_24
+  NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28 NBIT_A[3]_29
+  NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33 NBIT_A[3]_34
+  NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38 NBIT_A[3]_39
+  NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43 NBIT_A[3]_44
+  NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48 NBIT_A[3]_49
+  NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53 NBIT_A[3]_54
+  NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58 NBIT_A[3]_59
+  NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63 NBIT_B[0]_0 NBIT_B[0]_1
+  NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5 NBIT_B[0]_6 NBIT_B[0]_7
+  NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11 NBIT_B[0]_12 NBIT_B[0]_13
+  NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16 NBIT_B[0]_17 NBIT_B[0]_18
+  NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21 NBIT_B[0]_22 NBIT_B[0]_23
+  NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26 NBIT_B[0]_27 NBIT_B[0]_28
+  NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31 NBIT_B[0]_32 NBIT_B[0]_33
+  NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36 NBIT_B[0]_37 NBIT_B[0]_38
+  NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41 NBIT_B[0]_42 NBIT_B[0]_43
+  NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46 NBIT_B[0]_47 NBIT_B[0]_48
+  NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51 NBIT_B[0]_52 NBIT_B[0]_53
+  NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56 NBIT_B[0]_57 NBIT_B[0]_58
+  NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61 NBIT_B[0]_62 NBIT_B[0]_63
+  NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3 NBIT_B[1]_4 NBIT_B[1]_5
+  NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9 NBIT_B[1]_10 NBIT_B[1]_11
+  NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14 NBIT_B[1]_15 NBIT_B[1]_16
+  NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19 NBIT_B[1]_20 NBIT_B[1]_21
+  NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24 NBIT_B[1]_25 NBIT_B[1]_26
+  NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29 NBIT_B[1]_30 NBIT_B[1]_31
+  NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34 NBIT_B[1]_35 NBIT_B[1]_36
+  NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39 NBIT_B[1]_40 NBIT_B[1]_41
+  NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44 NBIT_B[1]_45 NBIT_B[1]_46
+  NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49 NBIT_B[1]_50 NBIT_B[1]_51
+  NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54 NBIT_B[1]_55 NBIT_B[1]_56
+  NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59 NBIT_B[1]_60 NBIT_B[1]_61
+  NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1 NBIT_B[2]_2 NBIT_B[2]_3
+  NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7 NBIT_B[2]_8 NBIT_B[2]_9
+  NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13 NBIT_B[2]_14
+  NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18 NBIT_B[2]_19
+  NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23 NBIT_B[2]_24
+  NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28 NBIT_B[2]_29
+  NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33 NBIT_B[2]_34
+  NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38 NBIT_B[2]_39
+  NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43 NBIT_B[2]_44
+  NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48 NBIT_B[2]_49
+  NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53 NBIT_B[2]_54
+  NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58 NBIT_B[2]_59
+  NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63 NBIT_B[3]_0 NBIT_B[3]_1
+  NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5 NBIT_B[3]_6 NBIT_B[3]_7
+  NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11 NBIT_B[3]_12 NBIT_B[3]_13
+  NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16 NBIT_B[3]_17 NBIT_B[3]_18
+  NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21 NBIT_B[3]_22 NBIT_B[3]_23
+  NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26 NBIT_B[3]_27 NBIT_B[3]_28
+  NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31 NBIT_B[3]_32 NBIT_B[3]_33
+  NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36 NBIT_B[3]_37 NBIT_B[3]_38
+  NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41 NBIT_B[3]_42 NBIT_B[3]_43
+  NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46 NBIT_B[3]_47 NBIT_B[3]_48
+  NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51 NBIT_B[3]_52 NBIT_B[3]_53
+  NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56 NBIT_B[3]_57 NBIT_B[3]_58
+  NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61 NBIT_B[3]_62 NBIT_B[3]_63
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5
+  NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11
+  NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17
+  NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23
+  NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29
+  NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35
+  NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41
+  NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47
+  NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53
+  NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59
+  NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1
+  NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7
+  NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13
+  NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19
+  NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25
+  NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31
+  NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37
+  NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43
+  NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49
+  NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55
+  NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61
+  NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1]
+  RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A
+  RE_B VDDCA VDDCA VDDCB VDDCB VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDCE VDDPE
+  VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
+  SRAMdpw64d256CCICD32320
XBCAPIROW ACTCLMP_A_1 ACTCLMP_B_1 CA_A[0] CA_A[1] CA_B[0] CA_B[1] BIT_A[0]_0
+  BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3 BIT_A[0]_4 BIT_A[0]_5 BIT_A[0]_6
+  BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9 BIT_A[0]_10 BIT_A[0]_11 BIT_A[0]_12
+  BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15 BIT_A[0]_16 BIT_A[0]_17 BIT_A[0]_18
+  BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21 BIT_A[0]_22 BIT_A[0]_23 BIT_A[0]_24
+  BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27 BIT_A[0]_28 BIT_A[0]_29 BIT_A[0]_30
+  BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33 BIT_A[0]_34 BIT_A[0]_35 BIT_A[0]_36
+  BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39 BIT_A[0]_40 BIT_A[0]_41 BIT_A[0]_42
+  BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45 BIT_A[0]_46 BIT_A[0]_47 BIT_A[0]_48
+  BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51 BIT_A[0]_52 BIT_A[0]_53 BIT_A[0]_54
+  BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57 BIT_A[0]_58 BIT_A[0]_59 BIT_A[0]_60
+  BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63 BIT_A[1]_0 BIT_A[1]_1 BIT_A[1]_2
+  BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5 BIT_A[1]_6 BIT_A[1]_7 BIT_A[1]_8
+  BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11 BIT_A[1]_12 BIT_A[1]_13 BIT_A[1]_14
+  BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17 BIT_A[1]_18 BIT_A[1]_19 BIT_A[1]_20
+  BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23 BIT_A[1]_24 BIT_A[1]_25 BIT_A[1]_26
+  BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29 BIT_A[1]_30 BIT_A[1]_31 BIT_A[1]_32
+  BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35 BIT_A[1]_36 BIT_A[1]_37 BIT_A[1]_38
+  BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41 BIT_A[1]_42 BIT_A[1]_43 BIT_A[1]_44
+  BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47 BIT_A[1]_48 BIT_A[1]_49 BIT_A[1]_50
+  BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53 BIT_A[1]_54 BIT_A[1]_55 BIT_A[1]_56
+  BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59 BIT_A[1]_60 BIT_A[1]_61 BIT_A[1]_62
+  BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1 BIT_A[2]_2 BIT_A[2]_3 BIT_A[2]_4
+  BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7 BIT_A[2]_8 BIT_A[2]_9 BIT_A[2]_10
+  BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13 BIT_A[2]_14 BIT_A[2]_15 BIT_A[2]_16
+  BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19 BIT_A[2]_20 BIT_A[2]_21 BIT_A[2]_22
+  BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25 BIT_A[2]_26 BIT_A[2]_27 BIT_A[2]_28
+  BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31 BIT_A[2]_32 BIT_A[2]_33 BIT_A[2]_34
+  BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37 BIT_A[2]_38 BIT_A[2]_39 BIT_A[2]_40
+  BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43 BIT_A[2]_44 BIT_A[2]_45 BIT_A[2]_46
+  BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49 BIT_A[2]_50 BIT_A[2]_51 BIT_A[2]_52
+  BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55 BIT_A[2]_56 BIT_A[2]_57 BIT_A[2]_58
+  BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61 BIT_A[2]_62 BIT_A[2]_63 BIT_A[3]_0
+  BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3 BIT_A[3]_4 BIT_A[3]_5 BIT_A[3]_6
+  BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9 BIT_A[3]_10 BIT_A[3]_11 BIT_A[3]_12
+  BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15 BIT_A[3]_16 BIT_A[3]_17 BIT_A[3]_18
+  BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21 BIT_A[3]_22 BIT_A[3]_23 BIT_A[3]_24
+  BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27 BIT_A[3]_28 BIT_A[3]_29 BIT_A[3]_30
+  BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33 BIT_A[3]_34 BIT_A[3]_35 BIT_A[3]_36
+  BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39 BIT_A[3]_40 BIT_A[3]_41 BIT_A[3]_42
+  BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45 BIT_A[3]_46 BIT_A[3]_47 BIT_A[3]_48
+  BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51 BIT_A[3]_52 BIT_A[3]_53 BIT_A[3]_54
+  BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57 BIT_A[3]_58 BIT_A[3]_59 BIT_A[3]_60
+  BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63 BIT_B[0]_0 BIT_B[0]_1 BIT_B[0]_2
+  BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5 BIT_B[0]_6 BIT_B[0]_7 BIT_B[0]_8
+  BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11 BIT_B[0]_12 BIT_B[0]_13 BIT_B[0]_14
+  BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17 BIT_B[0]_18 BIT_B[0]_19 BIT_B[0]_20
+  BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23 BIT_B[0]_24 BIT_B[0]_25 BIT_B[0]_26
+  BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29 BIT_B[0]_30 BIT_B[0]_31 BIT_B[0]_32
+  BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35 BIT_B[0]_36 BIT_B[0]_37 BIT_B[0]_38
+  BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41 BIT_B[0]_42 BIT_B[0]_43 BIT_B[0]_44
+  BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47 BIT_B[0]_48 BIT_B[0]_49 BIT_B[0]_50
+  BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53 BIT_B[0]_54 BIT_B[0]_55 BIT_B[0]_56
+  BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59 BIT_B[0]_60 BIT_B[0]_61 BIT_B[0]_62
+  BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1 BIT_B[1]_2 BIT_B[1]_3 BIT_B[1]_4
+  BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7 BIT_B[1]_8 BIT_B[1]_9 BIT_B[1]_10
+  BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13 BIT_B[1]_14 BIT_B[1]_15 BIT_B[1]_16
+  BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19 BIT_B[1]_20 BIT_B[1]_21 BIT_B[1]_22
+  BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25 BIT_B[1]_26 BIT_B[1]_27 BIT_B[1]_28
+  BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31 BIT_B[1]_32 BIT_B[1]_33 BIT_B[1]_34
+  BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37 BIT_B[1]_38 BIT_B[1]_39 BIT_B[1]_40
+  BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43 BIT_B[1]_44 BIT_B[1]_45 BIT_B[1]_46
+  BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49 BIT_B[1]_50 BIT_B[1]_51 BIT_B[1]_52
+  BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55 BIT_B[1]_56 BIT_B[1]_57 BIT_B[1]_58
+  BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61 BIT_B[1]_62 BIT_B[1]_63 BIT_B[2]_0
+  BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3 BIT_B[2]_4 BIT_B[2]_5 BIT_B[2]_6
+  BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9 BIT_B[2]_10 BIT_B[2]_11 BIT_B[2]_12
+  BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15 BIT_B[2]_16 BIT_B[2]_17 BIT_B[2]_18
+  BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21 BIT_B[2]_22 BIT_B[2]_23 BIT_B[2]_24
+  BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27 BIT_B[2]_28 BIT_B[2]_29 BIT_B[2]_30
+  BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33 BIT_B[2]_34 BIT_B[2]_35 BIT_B[2]_36
+  BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39 BIT_B[2]_40 BIT_B[2]_41 BIT_B[2]_42
+  BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45 BIT_B[2]_46 BIT_B[2]_47 BIT_B[2]_48
+  BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51 BIT_B[2]_52 BIT_B[2]_53 BIT_B[2]_54
+  BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57 BIT_B[2]_58 BIT_B[2]_59 BIT_B[2]_60
+  BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63 BIT_B[3]_0 BIT_B[3]_1 BIT_B[3]_2
+  BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5 BIT_B[3]_6 BIT_B[3]_7 BIT_B[3]_8
+  BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11 BIT_B[3]_12 BIT_B[3]_13 BIT_B[3]_14
+  BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17 BIT_B[3]_18 BIT_B[3]_19 BIT_B[3]_20
+  BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23 BIT_B[3]_24 BIT_B[3]_25 BIT_B[3]_26
+  BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29 BIT_B[3]_30 BIT_B[3]_31 BIT_B[3]_32
+  BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35 BIT_B[3]_36 BIT_B[3]_37 BIT_B[3]_38
+  BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41 BIT_B[3]_42 BIT_B[3]_43 BIT_B[3]_44
+  BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47 BIT_B[3]_48 BIT_B[3]_49 BIT_B[3]_50
+  BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53 BIT_B[3]_54 BIT_B[3]_55 BIT_B[3]_56
+  BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59 BIT_B[3]_60 BIT_B[3]_61 BIT_B[3]_62
+  BIT_B[3]_63 BNK_A BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1 DATAIN_A_2
+  DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7 DATAIN_A_8
+  DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13 DATAIN_A_14
+  DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19 DATAIN_A_20
+  DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25 DATAIN_A_26
+  DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31 DATAIN_A_32
+  DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38
+  DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44
+  DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50
+  DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56
+  DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62
+  DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3 DATAIN_B_4
+  DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9 DATAIN_B_10
+  DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15 DATAIN_B_16
+  DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21 DATAIN_B_22
+  DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27 DATAIN_B_28
+  DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34
+  DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40
+  DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46
+  DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52
+  DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58
+  DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B
+  GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8
+  GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16
+  GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24
+  GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32
+  GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40
+  GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48
+  GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56
+  GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0
+  GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9
+  GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17
+  GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25
+  GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33
+  GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41
+  GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49
+  GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57
+  GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 LOG0_DBL_A LOG0_DBL_B
+  NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2 NBIT_A[0]_3 NBIT_A[0]_4
+  NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8 NBIT_A[0]_9 NBIT_A[0]_10
+  NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13 NBIT_A[0]_14 NBIT_A[0]_15
+  NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18 NBIT_A[0]_19 NBIT_A[0]_20
+  NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23 NBIT_A[0]_24 NBIT_A[0]_25
+  NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28 NBIT_A[0]_29 NBIT_A[0]_30
+  NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33 NBIT_A[0]_34 NBIT_A[0]_35
+  NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38 NBIT_A[0]_39 NBIT_A[0]_40
+  NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43 NBIT_A[0]_44 NBIT_A[0]_45
+  NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48 NBIT_A[0]_49 NBIT_A[0]_50
+  NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53 NBIT_A[0]_54 NBIT_A[0]_55
+  NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58 NBIT_A[0]_59 NBIT_A[0]_60
+  NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63 NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2
+  NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5 NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8
+  NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11 NBIT_A[1]_12 NBIT_A[1]_13
+  NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16 NBIT_A[1]_17 NBIT_A[1]_18
+  NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21 NBIT_A[1]_22 NBIT_A[1]_23
+  NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26 NBIT_A[1]_27 NBIT_A[1]_28
+  NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31 NBIT_A[1]_32 NBIT_A[1]_33
+  NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36 NBIT_A[1]_37 NBIT_A[1]_38
+  NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41 NBIT_A[1]_42 NBIT_A[1]_43
+  NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46 NBIT_A[1]_47 NBIT_A[1]_48
+  NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51 NBIT_A[1]_52 NBIT_A[1]_53
+  NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56 NBIT_A[1]_57 NBIT_A[1]_58
+  NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61 NBIT_A[1]_62 NBIT_A[1]_63
+  NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3 NBIT_A[2]_4 NBIT_A[2]_5
+  NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9 NBIT_A[2]_10 NBIT_A[2]_11
+  NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14 NBIT_A[2]_15 NBIT_A[2]_16
+  NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19 NBIT_A[2]_20 NBIT_A[2]_21
+  NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24 NBIT_A[2]_25 NBIT_A[2]_26
+  NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29 NBIT_A[2]_30 NBIT_A[2]_31
+  NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34 NBIT_A[2]_35 NBIT_A[2]_36
+  NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39 NBIT_A[2]_40 NBIT_A[2]_41
+  NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44 NBIT_A[2]_45 NBIT_A[2]_46
+  NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49 NBIT_A[2]_50 NBIT_A[2]_51
+  NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54 NBIT_A[2]_55 NBIT_A[2]_56
+  NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59 NBIT_A[2]_60 NBIT_A[2]_61
+  NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1 NBIT_A[3]_2 NBIT_A[3]_3
+  NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7 NBIT_A[3]_8 NBIT_A[3]_9
+  NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13 NBIT_A[3]_14
+  NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18 NBIT_A[3]_19
+  NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23 NBIT_A[3]_24
+  NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28 NBIT_A[3]_29
+  NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33 NBIT_A[3]_34
+  NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38 NBIT_A[3]_39
+  NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43 NBIT_A[3]_44
+  NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48 NBIT_A[3]_49
+  NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53 NBIT_A[3]_54
+  NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58 NBIT_A[3]_59
+  NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63 NBIT_B[0]_0 NBIT_B[0]_1
+  NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5 NBIT_B[0]_6 NBIT_B[0]_7
+  NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11 NBIT_B[0]_12 NBIT_B[0]_13
+  NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16 NBIT_B[0]_17 NBIT_B[0]_18
+  NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21 NBIT_B[0]_22 NBIT_B[0]_23
+  NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26 NBIT_B[0]_27 NBIT_B[0]_28
+  NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31 NBIT_B[0]_32 NBIT_B[0]_33
+  NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36 NBIT_B[0]_37 NBIT_B[0]_38
+  NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41 NBIT_B[0]_42 NBIT_B[0]_43
+  NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46 NBIT_B[0]_47 NBIT_B[0]_48
+  NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51 NBIT_B[0]_52 NBIT_B[0]_53
+  NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56 NBIT_B[0]_57 NBIT_B[0]_58
+  NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61 NBIT_B[0]_62 NBIT_B[0]_63
+  NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3 NBIT_B[1]_4 NBIT_B[1]_5
+  NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9 NBIT_B[1]_10 NBIT_B[1]_11
+  NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14 NBIT_B[1]_15 NBIT_B[1]_16
+  NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19 NBIT_B[1]_20 NBIT_B[1]_21
+  NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24 NBIT_B[1]_25 NBIT_B[1]_26
+  NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29 NBIT_B[1]_30 NBIT_B[1]_31
+  NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34 NBIT_B[1]_35 NBIT_B[1]_36
+  NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39 NBIT_B[1]_40 NBIT_B[1]_41
+  NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44 NBIT_B[1]_45 NBIT_B[1]_46
+  NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49 NBIT_B[1]_50 NBIT_B[1]_51
+  NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54 NBIT_B[1]_55 NBIT_B[1]_56
+  NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59 NBIT_B[1]_60 NBIT_B[1]_61
+  NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1 NBIT_B[2]_2 NBIT_B[2]_3
+  NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7 NBIT_B[2]_8 NBIT_B[2]_9
+  NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13 NBIT_B[2]_14
+  NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18 NBIT_B[2]_19
+  NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23 NBIT_B[2]_24
+  NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28 NBIT_B[2]_29
+  NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33 NBIT_B[2]_34
+  NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38 NBIT_B[2]_39
+  NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43 NBIT_B[2]_44
+  NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48 NBIT_B[2]_49
+  NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53 NBIT_B[2]_54
+  NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58 NBIT_B[2]_59
+  NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63 NBIT_B[3]_0 NBIT_B[3]_1
+  NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5 NBIT_B[3]_6 NBIT_B[3]_7
+  NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11 NBIT_B[3]_12 NBIT_B[3]_13
+  NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16 NBIT_B[3]_17 NBIT_B[3]_18
+  NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21 NBIT_B[3]_22 NBIT_B[3]_23
+  NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26 NBIT_B[3]_27 NBIT_B[3]_28
+  NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31 NBIT_B[3]_32 NBIT_B[3]_33
+  NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36 NBIT_B[3]_37 NBIT_B[3]_38
+  NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41 NBIT_B[3]_42 NBIT_B[3]_43
+  NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46 NBIT_B[3]_47 NBIT_B[3]_48
+  NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51 NBIT_B[3]_52 NBIT_B[3]_53
+  NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56 NBIT_B[3]_57 NBIT_B[3]_58
+  NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61 NBIT_B[3]_62 NBIT_B[3]_63 NC_RET_ACT
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5
+  NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11
+  NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17
+  NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23
+  NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29
+  NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35
+  NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41
+  NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47
+  NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53
+  NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59
+  NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1
+  NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7
+  NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13
+  NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19
+  NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25
+  NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31
+  NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37
+  NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43
+  NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49
+  NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55
+  NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61
+  NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1]
+  RET_SHR_DEC1A[0] RET_SHR_DEC1A[1] RET_SHR_DEC1B[0] RET_SHR_DEC1B[1] RE_A
+  RE_B VDDCE VDDCA VDDCA VDDCB VDDCB VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE VDDPE
+  VDDPE VDDPE VDDPE VPW VPW VPW VPW VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
+  SRAMdpw64d256ICAPCCIO0
XCHANNEL ACTCLMP_A_0 ACTCLMP_B_0 BIT_A[0]_0 BIT_A[0]_1 BIT_A[0]_2 BIT_A[0]_3
+  BIT_A[0]_4 BIT_A[0]_5 BIT_A[0]_6 BIT_A[0]_7 BIT_A[0]_8 BIT_A[0]_9
+  BIT_A[0]_10 BIT_A[0]_11 BIT_A[0]_12 BIT_A[0]_13 BIT_A[0]_14 BIT_A[0]_15
+  BIT_A[0]_16 BIT_A[0]_17 BIT_A[0]_18 BIT_A[0]_19 BIT_A[0]_20 BIT_A[0]_21
+  BIT_A[0]_22 BIT_A[0]_23 BIT_A[0]_24 BIT_A[0]_25 BIT_A[0]_26 BIT_A[0]_27
+  BIT_A[0]_28 BIT_A[0]_29 BIT_A[0]_30 BIT_A[0]_31 BIT_A[0]_32 BIT_A[0]_33
+  BIT_A[0]_34 BIT_A[0]_35 BIT_A[0]_36 BIT_A[0]_37 BIT_A[0]_38 BIT_A[0]_39
+  BIT_A[0]_40 BIT_A[0]_41 BIT_A[0]_42 BIT_A[0]_43 BIT_A[0]_44 BIT_A[0]_45
+  BIT_A[0]_46 BIT_A[0]_47 BIT_A[0]_48 BIT_A[0]_49 BIT_A[0]_50 BIT_A[0]_51
+  BIT_A[0]_52 BIT_A[0]_53 BIT_A[0]_54 BIT_A[0]_55 BIT_A[0]_56 BIT_A[0]_57
+  BIT_A[0]_58 BIT_A[0]_59 BIT_A[0]_60 BIT_A[0]_61 BIT_A[0]_62 BIT_A[0]_63
+  BIT_A[1]_0 BIT_A[1]_1 BIT_A[1]_2 BIT_A[1]_3 BIT_A[1]_4 BIT_A[1]_5
+  BIT_A[1]_6 BIT_A[1]_7 BIT_A[1]_8 BIT_A[1]_9 BIT_A[1]_10 BIT_A[1]_11
+  BIT_A[1]_12 BIT_A[1]_13 BIT_A[1]_14 BIT_A[1]_15 BIT_A[1]_16 BIT_A[1]_17
+  BIT_A[1]_18 BIT_A[1]_19 BIT_A[1]_20 BIT_A[1]_21 BIT_A[1]_22 BIT_A[1]_23
+  BIT_A[1]_24 BIT_A[1]_25 BIT_A[1]_26 BIT_A[1]_27 BIT_A[1]_28 BIT_A[1]_29
+  BIT_A[1]_30 BIT_A[1]_31 BIT_A[1]_32 BIT_A[1]_33 BIT_A[1]_34 BIT_A[1]_35
+  BIT_A[1]_36 BIT_A[1]_37 BIT_A[1]_38 BIT_A[1]_39 BIT_A[1]_40 BIT_A[1]_41
+  BIT_A[1]_42 BIT_A[1]_43 BIT_A[1]_44 BIT_A[1]_45 BIT_A[1]_46 BIT_A[1]_47
+  BIT_A[1]_48 BIT_A[1]_49 BIT_A[1]_50 BIT_A[1]_51 BIT_A[1]_52 BIT_A[1]_53
+  BIT_A[1]_54 BIT_A[1]_55 BIT_A[1]_56 BIT_A[1]_57 BIT_A[1]_58 BIT_A[1]_59
+  BIT_A[1]_60 BIT_A[1]_61 BIT_A[1]_62 BIT_A[1]_63 BIT_A[2]_0 BIT_A[2]_1
+  BIT_A[2]_2 BIT_A[2]_3 BIT_A[2]_4 BIT_A[2]_5 BIT_A[2]_6 BIT_A[2]_7
+  BIT_A[2]_8 BIT_A[2]_9 BIT_A[2]_10 BIT_A[2]_11 BIT_A[2]_12 BIT_A[2]_13
+  BIT_A[2]_14 BIT_A[2]_15 BIT_A[2]_16 BIT_A[2]_17 BIT_A[2]_18 BIT_A[2]_19
+  BIT_A[2]_20 BIT_A[2]_21 BIT_A[2]_22 BIT_A[2]_23 BIT_A[2]_24 BIT_A[2]_25
+  BIT_A[2]_26 BIT_A[2]_27 BIT_A[2]_28 BIT_A[2]_29 BIT_A[2]_30 BIT_A[2]_31
+  BIT_A[2]_32 BIT_A[2]_33 BIT_A[2]_34 BIT_A[2]_35 BIT_A[2]_36 BIT_A[2]_37
+  BIT_A[2]_38 BIT_A[2]_39 BIT_A[2]_40 BIT_A[2]_41 BIT_A[2]_42 BIT_A[2]_43
+  BIT_A[2]_44 BIT_A[2]_45 BIT_A[2]_46 BIT_A[2]_47 BIT_A[2]_48 BIT_A[2]_49
+  BIT_A[2]_50 BIT_A[2]_51 BIT_A[2]_52 BIT_A[2]_53 BIT_A[2]_54 BIT_A[2]_55
+  BIT_A[2]_56 BIT_A[2]_57 BIT_A[2]_58 BIT_A[2]_59 BIT_A[2]_60 BIT_A[2]_61
+  BIT_A[2]_62 BIT_A[2]_63 BIT_A[3]_0 BIT_A[3]_1 BIT_A[3]_2 BIT_A[3]_3
+  BIT_A[3]_4 BIT_A[3]_5 BIT_A[3]_6 BIT_A[3]_7 BIT_A[3]_8 BIT_A[3]_9
+  BIT_A[3]_10 BIT_A[3]_11 BIT_A[3]_12 BIT_A[3]_13 BIT_A[3]_14 BIT_A[3]_15
+  BIT_A[3]_16 BIT_A[3]_17 BIT_A[3]_18 BIT_A[3]_19 BIT_A[3]_20 BIT_A[3]_21
+  BIT_A[3]_22 BIT_A[3]_23 BIT_A[3]_24 BIT_A[3]_25 BIT_A[3]_26 BIT_A[3]_27
+  BIT_A[3]_28 BIT_A[3]_29 BIT_A[3]_30 BIT_A[3]_31 BIT_A[3]_32 BIT_A[3]_33
+  BIT_A[3]_34 BIT_A[3]_35 BIT_A[3]_36 BIT_A[3]_37 BIT_A[3]_38 BIT_A[3]_39
+  BIT_A[3]_40 BIT_A[3]_41 BIT_A[3]_42 BIT_A[3]_43 BIT_A[3]_44 BIT_A[3]_45
+  BIT_A[3]_46 BIT_A[3]_47 BIT_A[3]_48 BIT_A[3]_49 BIT_A[3]_50 BIT_A[3]_51
+  BIT_A[3]_52 BIT_A[3]_53 BIT_A[3]_54 BIT_A[3]_55 BIT_A[3]_56 BIT_A[3]_57
+  BIT_A[3]_58 BIT_A[3]_59 BIT_A[3]_60 BIT_A[3]_61 BIT_A[3]_62 BIT_A[3]_63
+  BIT_B[0]_0 BIT_B[0]_1 BIT_B[0]_2 BIT_B[0]_3 BIT_B[0]_4 BIT_B[0]_5
+  BIT_B[0]_6 BIT_B[0]_7 BIT_B[0]_8 BIT_B[0]_9 BIT_B[0]_10 BIT_B[0]_11
+  BIT_B[0]_12 BIT_B[0]_13 BIT_B[0]_14 BIT_B[0]_15 BIT_B[0]_16 BIT_B[0]_17
+  BIT_B[0]_18 BIT_B[0]_19 BIT_B[0]_20 BIT_B[0]_21 BIT_B[0]_22 BIT_B[0]_23
+  BIT_B[0]_24 BIT_B[0]_25 BIT_B[0]_26 BIT_B[0]_27 BIT_B[0]_28 BIT_B[0]_29
+  BIT_B[0]_30 BIT_B[0]_31 BIT_B[0]_32 BIT_B[0]_33 BIT_B[0]_34 BIT_B[0]_35
+  BIT_B[0]_36 BIT_B[0]_37 BIT_B[0]_38 BIT_B[0]_39 BIT_B[0]_40 BIT_B[0]_41
+  BIT_B[0]_42 BIT_B[0]_43 BIT_B[0]_44 BIT_B[0]_45 BIT_B[0]_46 BIT_B[0]_47
+  BIT_B[0]_48 BIT_B[0]_49 BIT_B[0]_50 BIT_B[0]_51 BIT_B[0]_52 BIT_B[0]_53
+  BIT_B[0]_54 BIT_B[0]_55 BIT_B[0]_56 BIT_B[0]_57 BIT_B[0]_58 BIT_B[0]_59
+  BIT_B[0]_60 BIT_B[0]_61 BIT_B[0]_62 BIT_B[0]_63 BIT_B[1]_0 BIT_B[1]_1
+  BIT_B[1]_2 BIT_B[1]_3 BIT_B[1]_4 BIT_B[1]_5 BIT_B[1]_6 BIT_B[1]_7
+  BIT_B[1]_8 BIT_B[1]_9 BIT_B[1]_10 BIT_B[1]_11 BIT_B[1]_12 BIT_B[1]_13
+  BIT_B[1]_14 BIT_B[1]_15 BIT_B[1]_16 BIT_B[1]_17 BIT_B[1]_18 BIT_B[1]_19
+  BIT_B[1]_20 BIT_B[1]_21 BIT_B[1]_22 BIT_B[1]_23 BIT_B[1]_24 BIT_B[1]_25
+  BIT_B[1]_26 BIT_B[1]_27 BIT_B[1]_28 BIT_B[1]_29 BIT_B[1]_30 BIT_B[1]_31
+  BIT_B[1]_32 BIT_B[1]_33 BIT_B[1]_34 BIT_B[1]_35 BIT_B[1]_36 BIT_B[1]_37
+  BIT_B[1]_38 BIT_B[1]_39 BIT_B[1]_40 BIT_B[1]_41 BIT_B[1]_42 BIT_B[1]_43
+  BIT_B[1]_44 BIT_B[1]_45 BIT_B[1]_46 BIT_B[1]_47 BIT_B[1]_48 BIT_B[1]_49
+  BIT_B[1]_50 BIT_B[1]_51 BIT_B[1]_52 BIT_B[1]_53 BIT_B[1]_54 BIT_B[1]_55
+  BIT_B[1]_56 BIT_B[1]_57 BIT_B[1]_58 BIT_B[1]_59 BIT_B[1]_60 BIT_B[1]_61
+  BIT_B[1]_62 BIT_B[1]_63 BIT_B[2]_0 BIT_B[2]_1 BIT_B[2]_2 BIT_B[2]_3
+  BIT_B[2]_4 BIT_B[2]_5 BIT_B[2]_6 BIT_B[2]_7 BIT_B[2]_8 BIT_B[2]_9
+  BIT_B[2]_10 BIT_B[2]_11 BIT_B[2]_12 BIT_B[2]_13 BIT_B[2]_14 BIT_B[2]_15
+  BIT_B[2]_16 BIT_B[2]_17 BIT_B[2]_18 BIT_B[2]_19 BIT_B[2]_20 BIT_B[2]_21
+  BIT_B[2]_22 BIT_B[2]_23 BIT_B[2]_24 BIT_B[2]_25 BIT_B[2]_26 BIT_B[2]_27
+  BIT_B[2]_28 BIT_B[2]_29 BIT_B[2]_30 BIT_B[2]_31 BIT_B[2]_32 BIT_B[2]_33
+  BIT_B[2]_34 BIT_B[2]_35 BIT_B[2]_36 BIT_B[2]_37 BIT_B[2]_38 BIT_B[2]_39
+  BIT_B[2]_40 BIT_B[2]_41 BIT_B[2]_42 BIT_B[2]_43 BIT_B[2]_44 BIT_B[2]_45
+  BIT_B[2]_46 BIT_B[2]_47 BIT_B[2]_48 BIT_B[2]_49 BIT_B[2]_50 BIT_B[2]_51
+  BIT_B[2]_52 BIT_B[2]_53 BIT_B[2]_54 BIT_B[2]_55 BIT_B[2]_56 BIT_B[2]_57
+  BIT_B[2]_58 BIT_B[2]_59 BIT_B[2]_60 BIT_B[2]_61 BIT_B[2]_62 BIT_B[2]_63
+  BIT_B[3]_0 BIT_B[3]_1 BIT_B[3]_2 BIT_B[3]_3 BIT_B[3]_4 BIT_B[3]_5
+  BIT_B[3]_6 BIT_B[3]_7 BIT_B[3]_8 BIT_B[3]_9 BIT_B[3]_10 BIT_B[3]_11
+  BIT_B[3]_12 BIT_B[3]_13 BIT_B[3]_14 BIT_B[3]_15 BIT_B[3]_16 BIT_B[3]_17
+  BIT_B[3]_18 BIT_B[3]_19 BIT_B[3]_20 BIT_B[3]_21 BIT_B[3]_22 BIT_B[3]_23
+  BIT_B[3]_24 BIT_B[3]_25 BIT_B[3]_26 BIT_B[3]_27 BIT_B[3]_28 BIT_B[3]_29
+  BIT_B[3]_30 BIT_B[3]_31 BIT_B[3]_32 BIT_B[3]_33 BIT_B[3]_34 BIT_B[3]_35
+  BIT_B[3]_36 BIT_B[3]_37 BIT_B[3]_38 BIT_B[3]_39 BIT_B[3]_40 BIT_B[3]_41
+  BIT_B[3]_42 BIT_B[3]_43 BIT_B[3]_44 BIT_B[3]_45 BIT_B[3]_46 BIT_B[3]_47
+  BIT_B[3]_48 BIT_B[3]_49 BIT_B[3]_50 BIT_B[3]_51 BIT_B[3]_52 BIT_B[3]_53
+  BIT_B[3]_54 BIT_B[3]_55 BIT_B[3]_56 BIT_B[3]_57 BIT_B[3]_58 BIT_B[3]_59
+  BIT_B[3]_60 BIT_B[3]_61 BIT_B[3]_62 BIT_B[3]_63 BNK_A BNK_B CA_A[0] CA_A[1]
+  CA_B[0] CA_B[1] CLK_A CLK_B DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3
+  DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9
+  DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15
+  DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21
+  DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27
+  DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31 DATAIN_A_32 DATAIN_A_33
+  DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38 DATAIN_A_39
+  DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44 DATAIN_A_45
+  DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50 DATAIN_A_51
+  DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56 DATAIN_A_57
+  DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62 DATAIN_A_63
+  DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3 DATAIN_B_4 DATAIN_B_5
+  DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9 DATAIN_B_10 DATAIN_B_11
+  DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15 DATAIN_B_16 DATAIN_B_17
+  DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21 DATAIN_B_22 DATAIN_B_23
+  DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27 DATAIN_B_28 DATAIN_B_29
+  DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35
+  DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41
+  DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47
+  DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53
+  DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59
+  DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1
+  GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10
+  GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18
+  GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26
+  GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34
+  GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42
+  GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50
+  GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58
+  GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2
+  GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11
+  GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19
+  GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27
+  GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35
+  GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43
+  GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51
+  GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59
+  GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 ACTCLMP_A_1 ACTCLMP_B_1 LOG0_DBL_A
+  LOG0_DBL_B NACT NBIT_A[0]_0 NBIT_A[0]_1 NBIT_A[0]_2 NBIT_A[0]_3 NBIT_A[0]_4
+  NBIT_A[0]_5 NBIT_A[0]_6 NBIT_A[0]_7 NBIT_A[0]_8 NBIT_A[0]_9 NBIT_A[0]_10
+  NBIT_A[0]_11 NBIT_A[0]_12 NBIT_A[0]_13 NBIT_A[0]_14 NBIT_A[0]_15
+  NBIT_A[0]_16 NBIT_A[0]_17 NBIT_A[0]_18 NBIT_A[0]_19 NBIT_A[0]_20
+  NBIT_A[0]_21 NBIT_A[0]_22 NBIT_A[0]_23 NBIT_A[0]_24 NBIT_A[0]_25
+  NBIT_A[0]_26 NBIT_A[0]_27 NBIT_A[0]_28 NBIT_A[0]_29 NBIT_A[0]_30
+  NBIT_A[0]_31 NBIT_A[0]_32 NBIT_A[0]_33 NBIT_A[0]_34 NBIT_A[0]_35
+  NBIT_A[0]_36 NBIT_A[0]_37 NBIT_A[0]_38 NBIT_A[0]_39 NBIT_A[0]_40
+  NBIT_A[0]_41 NBIT_A[0]_42 NBIT_A[0]_43 NBIT_A[0]_44 NBIT_A[0]_45
+  NBIT_A[0]_46 NBIT_A[0]_47 NBIT_A[0]_48 NBIT_A[0]_49 NBIT_A[0]_50
+  NBIT_A[0]_51 NBIT_A[0]_52 NBIT_A[0]_53 NBIT_A[0]_54 NBIT_A[0]_55
+  NBIT_A[0]_56 NBIT_A[0]_57 NBIT_A[0]_58 NBIT_A[0]_59 NBIT_A[0]_60
+  NBIT_A[0]_61 NBIT_A[0]_62 NBIT_A[0]_63 NBIT_A[1]_0 NBIT_A[1]_1 NBIT_A[1]_2
+  NBIT_A[1]_3 NBIT_A[1]_4 NBIT_A[1]_5 NBIT_A[1]_6 NBIT_A[1]_7 NBIT_A[1]_8
+  NBIT_A[1]_9 NBIT_A[1]_10 NBIT_A[1]_11 NBIT_A[1]_12 NBIT_A[1]_13
+  NBIT_A[1]_14 NBIT_A[1]_15 NBIT_A[1]_16 NBIT_A[1]_17 NBIT_A[1]_18
+  NBIT_A[1]_19 NBIT_A[1]_20 NBIT_A[1]_21 NBIT_A[1]_22 NBIT_A[1]_23
+  NBIT_A[1]_24 NBIT_A[1]_25 NBIT_A[1]_26 NBIT_A[1]_27 NBIT_A[1]_28
+  NBIT_A[1]_29 NBIT_A[1]_30 NBIT_A[1]_31 NBIT_A[1]_32 NBIT_A[1]_33
+  NBIT_A[1]_34 NBIT_A[1]_35 NBIT_A[1]_36 NBIT_A[1]_37 NBIT_A[1]_38
+  NBIT_A[1]_39 NBIT_A[1]_40 NBIT_A[1]_41 NBIT_A[1]_42 NBIT_A[1]_43
+  NBIT_A[1]_44 NBIT_A[1]_45 NBIT_A[1]_46 NBIT_A[1]_47 NBIT_A[1]_48
+  NBIT_A[1]_49 NBIT_A[1]_50 NBIT_A[1]_51 NBIT_A[1]_52 NBIT_A[1]_53
+  NBIT_A[1]_54 NBIT_A[1]_55 NBIT_A[1]_56 NBIT_A[1]_57 NBIT_A[1]_58
+  NBIT_A[1]_59 NBIT_A[1]_60 NBIT_A[1]_61 NBIT_A[1]_62 NBIT_A[1]_63
+  NBIT_A[2]_0 NBIT_A[2]_1 NBIT_A[2]_2 NBIT_A[2]_3 NBIT_A[2]_4 NBIT_A[2]_5
+  NBIT_A[2]_6 NBIT_A[2]_7 NBIT_A[2]_8 NBIT_A[2]_9 NBIT_A[2]_10 NBIT_A[2]_11
+  NBIT_A[2]_12 NBIT_A[2]_13 NBIT_A[2]_14 NBIT_A[2]_15 NBIT_A[2]_16
+  NBIT_A[2]_17 NBIT_A[2]_18 NBIT_A[2]_19 NBIT_A[2]_20 NBIT_A[2]_21
+  NBIT_A[2]_22 NBIT_A[2]_23 NBIT_A[2]_24 NBIT_A[2]_25 NBIT_A[2]_26
+  NBIT_A[2]_27 NBIT_A[2]_28 NBIT_A[2]_29 NBIT_A[2]_30 NBIT_A[2]_31
+  NBIT_A[2]_32 NBIT_A[2]_33 NBIT_A[2]_34 NBIT_A[2]_35 NBIT_A[2]_36
+  NBIT_A[2]_37 NBIT_A[2]_38 NBIT_A[2]_39 NBIT_A[2]_40 NBIT_A[2]_41
+  NBIT_A[2]_42 NBIT_A[2]_43 NBIT_A[2]_44 NBIT_A[2]_45 NBIT_A[2]_46
+  NBIT_A[2]_47 NBIT_A[2]_48 NBIT_A[2]_49 NBIT_A[2]_50 NBIT_A[2]_51
+  NBIT_A[2]_52 NBIT_A[2]_53 NBIT_A[2]_54 NBIT_A[2]_55 NBIT_A[2]_56
+  NBIT_A[2]_57 NBIT_A[2]_58 NBIT_A[2]_59 NBIT_A[2]_60 NBIT_A[2]_61
+  NBIT_A[2]_62 NBIT_A[2]_63 NBIT_A[3]_0 NBIT_A[3]_1 NBIT_A[3]_2 NBIT_A[3]_3
+  NBIT_A[3]_4 NBIT_A[3]_5 NBIT_A[3]_6 NBIT_A[3]_7 NBIT_A[3]_8 NBIT_A[3]_9
+  NBIT_A[3]_10 NBIT_A[3]_11 NBIT_A[3]_12 NBIT_A[3]_13 NBIT_A[3]_14
+  NBIT_A[3]_15 NBIT_A[3]_16 NBIT_A[3]_17 NBIT_A[3]_18 NBIT_A[3]_19
+  NBIT_A[3]_20 NBIT_A[3]_21 NBIT_A[3]_22 NBIT_A[3]_23 NBIT_A[3]_24
+  NBIT_A[3]_25 NBIT_A[3]_26 NBIT_A[3]_27 NBIT_A[3]_28 NBIT_A[3]_29
+  NBIT_A[3]_30 NBIT_A[3]_31 NBIT_A[3]_32 NBIT_A[3]_33 NBIT_A[3]_34
+  NBIT_A[3]_35 NBIT_A[3]_36 NBIT_A[3]_37 NBIT_A[3]_38 NBIT_A[3]_39
+  NBIT_A[3]_40 NBIT_A[3]_41 NBIT_A[3]_42 NBIT_A[3]_43 NBIT_A[3]_44
+  NBIT_A[3]_45 NBIT_A[3]_46 NBIT_A[3]_47 NBIT_A[3]_48 NBIT_A[3]_49
+  NBIT_A[3]_50 NBIT_A[3]_51 NBIT_A[3]_52 NBIT_A[3]_53 NBIT_A[3]_54
+  NBIT_A[3]_55 NBIT_A[3]_56 NBIT_A[3]_57 NBIT_A[3]_58 NBIT_A[3]_59
+  NBIT_A[3]_60 NBIT_A[3]_61 NBIT_A[3]_62 NBIT_A[3]_63 NBIT_B[0]_0 NBIT_B[0]_1
+  NBIT_B[0]_2 NBIT_B[0]_3 NBIT_B[0]_4 NBIT_B[0]_5 NBIT_B[0]_6 NBIT_B[0]_7
+  NBIT_B[0]_8 NBIT_B[0]_9 NBIT_B[0]_10 NBIT_B[0]_11 NBIT_B[0]_12 NBIT_B[0]_13
+  NBIT_B[0]_14 NBIT_B[0]_15 NBIT_B[0]_16 NBIT_B[0]_17 NBIT_B[0]_18
+  NBIT_B[0]_19 NBIT_B[0]_20 NBIT_B[0]_21 NBIT_B[0]_22 NBIT_B[0]_23
+  NBIT_B[0]_24 NBIT_B[0]_25 NBIT_B[0]_26 NBIT_B[0]_27 NBIT_B[0]_28
+  NBIT_B[0]_29 NBIT_B[0]_30 NBIT_B[0]_31 NBIT_B[0]_32 NBIT_B[0]_33
+  NBIT_B[0]_34 NBIT_B[0]_35 NBIT_B[0]_36 NBIT_B[0]_37 NBIT_B[0]_38
+  NBIT_B[0]_39 NBIT_B[0]_40 NBIT_B[0]_41 NBIT_B[0]_42 NBIT_B[0]_43
+  NBIT_B[0]_44 NBIT_B[0]_45 NBIT_B[0]_46 NBIT_B[0]_47 NBIT_B[0]_48
+  NBIT_B[0]_49 NBIT_B[0]_50 NBIT_B[0]_51 NBIT_B[0]_52 NBIT_B[0]_53
+  NBIT_B[0]_54 NBIT_B[0]_55 NBIT_B[0]_56 NBIT_B[0]_57 NBIT_B[0]_58
+  NBIT_B[0]_59 NBIT_B[0]_60 NBIT_B[0]_61 NBIT_B[0]_62 NBIT_B[0]_63
+  NBIT_B[1]_0 NBIT_B[1]_1 NBIT_B[1]_2 NBIT_B[1]_3 NBIT_B[1]_4 NBIT_B[1]_5
+  NBIT_B[1]_6 NBIT_B[1]_7 NBIT_B[1]_8 NBIT_B[1]_9 NBIT_B[1]_10 NBIT_B[1]_11
+  NBIT_B[1]_12 NBIT_B[1]_13 NBIT_B[1]_14 NBIT_B[1]_15 NBIT_B[1]_16
+  NBIT_B[1]_17 NBIT_B[1]_18 NBIT_B[1]_19 NBIT_B[1]_20 NBIT_B[1]_21
+  NBIT_B[1]_22 NBIT_B[1]_23 NBIT_B[1]_24 NBIT_B[1]_25 NBIT_B[1]_26
+  NBIT_B[1]_27 NBIT_B[1]_28 NBIT_B[1]_29 NBIT_B[1]_30 NBIT_B[1]_31
+  NBIT_B[1]_32 NBIT_B[1]_33 NBIT_B[1]_34 NBIT_B[1]_35 NBIT_B[1]_36
+  NBIT_B[1]_37 NBIT_B[1]_38 NBIT_B[1]_39 NBIT_B[1]_40 NBIT_B[1]_41
+  NBIT_B[1]_42 NBIT_B[1]_43 NBIT_B[1]_44 NBIT_B[1]_45 NBIT_B[1]_46
+  NBIT_B[1]_47 NBIT_B[1]_48 NBIT_B[1]_49 NBIT_B[1]_50 NBIT_B[1]_51
+  NBIT_B[1]_52 NBIT_B[1]_53 NBIT_B[1]_54 NBIT_B[1]_55 NBIT_B[1]_56
+  NBIT_B[1]_57 NBIT_B[1]_58 NBIT_B[1]_59 NBIT_B[1]_60 NBIT_B[1]_61
+  NBIT_B[1]_62 NBIT_B[1]_63 NBIT_B[2]_0 NBIT_B[2]_1 NBIT_B[2]_2 NBIT_B[2]_3
+  NBIT_B[2]_4 NBIT_B[2]_5 NBIT_B[2]_6 NBIT_B[2]_7 NBIT_B[2]_8 NBIT_B[2]_9
+  NBIT_B[2]_10 NBIT_B[2]_11 NBIT_B[2]_12 NBIT_B[2]_13 NBIT_B[2]_14
+  NBIT_B[2]_15 NBIT_B[2]_16 NBIT_B[2]_17 NBIT_B[2]_18 NBIT_B[2]_19
+  NBIT_B[2]_20 NBIT_B[2]_21 NBIT_B[2]_22 NBIT_B[2]_23 NBIT_B[2]_24
+  NBIT_B[2]_25 NBIT_B[2]_26 NBIT_B[2]_27 NBIT_B[2]_28 NBIT_B[2]_29
+  NBIT_B[2]_30 NBIT_B[2]_31 NBIT_B[2]_32 NBIT_B[2]_33 NBIT_B[2]_34
+  NBIT_B[2]_35 NBIT_B[2]_36 NBIT_B[2]_37 NBIT_B[2]_38 NBIT_B[2]_39
+  NBIT_B[2]_40 NBIT_B[2]_41 NBIT_B[2]_42 NBIT_B[2]_43 NBIT_B[2]_44
+  NBIT_B[2]_45 NBIT_B[2]_46 NBIT_B[2]_47 NBIT_B[2]_48 NBIT_B[2]_49
+  NBIT_B[2]_50 NBIT_B[2]_51 NBIT_B[2]_52 NBIT_B[2]_53 NBIT_B[2]_54
+  NBIT_B[2]_55 NBIT_B[2]_56 NBIT_B[2]_57 NBIT_B[2]_58 NBIT_B[2]_59
+  NBIT_B[2]_60 NBIT_B[2]_61 NBIT_B[2]_62 NBIT_B[2]_63 NBIT_B[3]_0 NBIT_B[3]_1
+  NBIT_B[3]_2 NBIT_B[3]_3 NBIT_B[3]_4 NBIT_B[3]_5 NBIT_B[3]_6 NBIT_B[3]_7
+  NBIT_B[3]_8 NBIT_B[3]_9 NBIT_B[3]_10 NBIT_B[3]_11 NBIT_B[3]_12 NBIT_B[3]_13
+  NBIT_B[3]_14 NBIT_B[3]_15 NBIT_B[3]_16 NBIT_B[3]_17 NBIT_B[3]_18
+  NBIT_B[3]_19 NBIT_B[3]_20 NBIT_B[3]_21 NBIT_B[3]_22 NBIT_B[3]_23
+  NBIT_B[3]_24 NBIT_B[3]_25 NBIT_B[3]_26 NBIT_B[3]_27 NBIT_B[3]_28
+  NBIT_B[3]_29 NBIT_B[3]_30 NBIT_B[3]_31 NBIT_B[3]_32 NBIT_B[3]_33
+  NBIT_B[3]_34 NBIT_B[3]_35 NBIT_B[3]_36 NBIT_B[3]_37 NBIT_B[3]_38
+  NBIT_B[3]_39 NBIT_B[3]_40 NBIT_B[3]_41 NBIT_B[3]_42 NBIT_B[3]_43
+  NBIT_B[3]_44 NBIT_B[3]_45 NBIT_B[3]_46 NBIT_B[3]_47 NBIT_B[3]_48
+  NBIT_B[3]_49 NBIT_B[3]_50 NBIT_B[3]_51 NBIT_B[3]_52 NBIT_B[3]_53
+  NBIT_B[3]_54 NBIT_B[3]_55 NBIT_B[3]_56 NBIT_B[3]_57 NBIT_B[3]_58
+  NBIT_B[3]_59 NBIT_B[3]_60 NBIT_B[3]_61 NBIT_B[3]_62 NBIT_B[3]_63
+  NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT
+  NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5
+  NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11
+  NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17
+  NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23
+  NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29
+  NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35
+  NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41
+  NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47
+  NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53
+  NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59
+  NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1
+  NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7
+  NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13
+  NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19
+  NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25
+  NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31
+  NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37
+  NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43
+  NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49
+  NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55
+  NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61
+  NWGSEL_B_62 NWGSEL_B_63 NWL_CLK_A NWL_CLK_B NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RE_A
+  RE_B VDDCA VDDCB VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDPE VPW WE_A WE_B WRA_MA
+  WRB_MA WTE_A WTE_B SRAMdpw64d256COLMXDN32320
.ENDS SRAMdpw64d256SGAR0_64_32_32_0_S
****
.SUBCKT SRAMdpw64d256B_64_32_32_0 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1]
+  ADDR_B[0] ADDR_B[1] BNK_A BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1
+  DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7
+  DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13
+  DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19
+  DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25
+  DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31
+  DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37
+  DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43
+  DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49
+  DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55
+  DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61
+  DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3
+  DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9
+  DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15
+  DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21
+  DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27
+  DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33
+  DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39
+  DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45
+  DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51
+  DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57
+  DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63
+  DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7
+  GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15
+  GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23
+  GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31
+  GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39
+  GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47
+  GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55
+  GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63
+  GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8
+  GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16
+  GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24
+  GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32
+  GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40
+  GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48
+  GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56
+  GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 LOG0_DBL_A
+  LOG0_DBL_B NACT NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B
+  NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3
+  NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9
+  NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15
+  NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21
+  NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27
+  NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33
+  NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39
+  NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45
+  NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51
+  NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57
+  NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63
+  NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5
+  NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11
+  NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17
+  NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23
+  NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29
+  NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35
+  NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41
+  NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47
+  NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53
+  NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59
+  NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63 NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RE_A
+  RE_B VDDC VDDPE VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256B_64_32_32_0: 159219 flat devices **
XBANKB ACTCLMP_A_3 ACTCLMP_A ACTCLMP_B_1 ACTCLMP_B BNK_A BNK_B ADDR_A[0]
+  ADDR_A[1] ADDR_B[0] ADDR_B[1] CLK_A CLK_B DATAIN_A_0 DATAIN_A_1 DATAIN_A_2
+  DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7 DATAIN_A_8
+  DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13 DATAIN_A_14
+  DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19 DATAIN_A_20
+  DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25 DATAIN_A_26
+  DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31 DATAIN_A_32
+  DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38
+  DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44
+  DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50
+  DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56
+  DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62
+  DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3 DATAIN_B_4
+  DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9 DATAIN_B_10
+  DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15 DATAIN_B_16
+  DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21 DATAIN_B_22
+  DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27 DATAIN_B_28
+  DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34
+  DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40
+  DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46
+  DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52
+  DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58
+  DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B
+  GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8
+  GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16
+  GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24
+  GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32
+  GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40
+  GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48
+  GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56
+  GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0
+  GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9
+  GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17
+  GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25
+  GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33
+  GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41
+  GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49
+  GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57
+  GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 LOG0_DBL_A LOG0_DBL_B
+  NACT NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B
+  NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4
+  NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10
+  NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16
+  NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22
+  NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28
+  NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34
+  NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40
+  NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46
+  NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52
+  NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58
+  NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0
+  NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6
+  NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12
+  NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18
+  NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24
+  NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30
+  NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36
+  NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42
+  NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48
+  NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54
+  NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60
+  NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63 NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2]
+  NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7]
+  NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4]
+  NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1]
+  NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6]
+  NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3]
+  NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0]
+  NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1]
+  NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RE_A RE_B VDDCA
+  VDDCB VDDC VDDPE VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
+  SRAMdpw64d256SGAR0_64_32_32_0_S
.ENDS SRAMdpw64d256B_64_32_32_0
****
.SUBCKT SRAMdpw64d256ARRAYWLOGIC_256_64 ACTCLMP_A ACTCLMP_B ADDR_A[0]
+  ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1
+  DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6 DATAIN_A_7
+  DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12 DATAIN_A_13
+  DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18 DATAIN_A_19
+  DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24 DATAIN_A_25
+  DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30 DATAIN_A_31
+  DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36 DATAIN_A_37
+  DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42 DATAIN_A_43
+  DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48 DATAIN_A_49
+  DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54 DATAIN_A_55
+  DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60 DATAIN_A_61
+  DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2 DATAIN_B_3
+  DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8 DATAIN_B_9
+  DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14 DATAIN_B_15
+  DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20 DATAIN_B_21
+  DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26 DATAIN_B_27
+  DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32 DATAIN_B_33
+  DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38 DATAIN_B_39
+  DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44 DATAIN_B_45
+  DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50 DATAIN_B_51
+  DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56 DATAIN_B_57
+  DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62 DATAIN_B_63
+  DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7
+  GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15
+  GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23
+  GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31
+  GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39
+  GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47
+  GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55
+  GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63
+  GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8
+  GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16
+  GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24
+  GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32
+  GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40
+  GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48
+  GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56
+  GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 LOG0_DBL_A
+  LOG0_DBL_B NACT NC_RET_ACT NDFTRAMBYP_A NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B
+  NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0 NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3
+  NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9
+  NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15
+  NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21
+  NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27
+  NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33
+  NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39
+  NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45
+  NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51
+  NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57
+  NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63
+  NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5
+  NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11
+  NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17
+  NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23
+  NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29
+  NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35
+  NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41
+  NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47
+  NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53
+  NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59
+  NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63 NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RE_A
+  RE_B VDDC VDDPE VPW WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B
** SRAMdpw64d256ARRAYWLOGIC_256_64: 159219 flat devices **
XSLICE0 ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4
+  DATAIN_A_5 DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10
+  DATAIN_A_11 DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16
+  DATAIN_A_17 DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22
+  DATAIN_A_23 DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28
+  DATAIN_A_29 DATAIN_A_30 DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34
+  DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40
+  DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46
+  DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52
+  DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58
+  DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0
+  DATAIN_B_1 DATAIN_B_2 DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6
+  DATAIN_B_7 DATAIN_B_8 DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12
+  DATAIN_B_13 DATAIN_B_14 DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18
+  DATAIN_B_19 DATAIN_B_20 DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24
+  DATAIN_B_25 DATAIN_B_26 DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30
+  DATAIN_B_31 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36
+  DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42
+  DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48
+  DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54
+  DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60
+  DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2
+  GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11
+  GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19
+  GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27
+  GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35
+  GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43
+  GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51
+  GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59
+  GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4
+  GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13
+  GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21
+  GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29
+  GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37
+  GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45
+  GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53
+  GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61
+  GDL_B_62 GDL_B_63 LOG0_DBL_A LOG0_DBL_B NACT NC_RET_ACT NDFTRAMBYP_A
+  NDFTRAMBYP_B NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B NRETHVT NRETNVT NWGSEL_A_0
+  NWGSEL_A_1 NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6
+  NWGSEL_A_7 NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12
+  NWGSEL_A_13 NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18
+  NWGSEL_A_19 NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24
+  NWGSEL_A_25 NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30
+  NWGSEL_A_31 NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36
+  NWGSEL_A_37 NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42
+  NWGSEL_A_43 NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48
+  NWGSEL_A_49 NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54
+  NWGSEL_A_55 NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60
+  NWGSEL_A_61 NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2
+  NWGSEL_B_3 NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8
+  NWGSEL_B_9 NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14
+  NWGSEL_B_15 NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20
+  NWGSEL_B_21 NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26
+  NWGSEL_B_27 NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32
+  NWGSEL_B_33 NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38
+  NWGSEL_B_39 NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44
+  NWGSEL_B_45 NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50
+  NWGSEL_B_51 NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56
+  NWGSEL_B_57 NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62
+  NWGSEL_B_63 NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3]
+  NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0]
+  NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5]
+  NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2]
+  NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7]
+  NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4]
+  NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1]
+  NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2]
+  NXPDEC3_B[3] RETA[0] RETA[1] RETB[0] RETB[1] RE_A RE_B VDDC VDDPE VPW WE_A
+  WE_B WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256B_64_32_32_0
.ENDS SRAMdpw64d256ARRAYWLOGIC_256_64
****
.SUBCKT SRAMdpw64d256CNTL_1V ACTCLMP ACTCLMP_A ACTCLMP_B ACT_CTLM BDFTRAMBYP_A
+  BDFTRAMBYP_B BPENSOA BPENSOB BPSOA[0] BPSOA[1] BPSOB[0] BPSOB[1] BSEL_D_A
+  BSEL_D_B BSEL_SI_A BSEL_SI_B BSEL_TD_A BSEL_TD_B BSOA[0] BSOA[1] BSOB[0]
+  BSOB[1] CAA[0] CAA[1] CAA[2] CAA[3] CAB[0] CAB[1] CAB[2] CAB[3] CADDR_A[2]
+  CADDR_A[3] CADDR_B[2] CADDR_B[3] CAYA[0] CAYA[1] CAYA[2] CAYA[3] CAYB[0]
+  CAYB[1] CAYB[2] CAYB[3] CENA CENB CENYA CENYB CLKA CLKB COLLDISN CRE1 CRE2
+  DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11]
+  DA[12] DA[13] DA[14] DA[15] DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7]
+  DB[8] DB[9] DB[10] DB[11] DB[12] DB[13] DB[14] DB[15] DFTRAMBYP
+  DFTRAMBYP_BUF_A DFTRAMBYP_BUF_B EMAA[0] EMAA[1] EMAA[2] EMAA_DEP2[0]
+  EMAA_DEP2[1] EMAA_DEP2[2] EMAB[0] EMAB[1] EMAB[2] EMAB_DEP2[0] EMAB_DEP2[1]
+  EMAB_DEP2[2] EMAWA[0] EMAWA[1] EMAWA_DEP2[0] EMAWA_DEP2[1] EMAWB[0]
+  EMAWB[1] EMAWB_DEP2[0] EMAWB_DEP2[1] GWENA GWENB GWENYA GWENYB LOG0
+  LOG0_CRE1 LOG0_CRE2 LOG0_DBL LOG0_PG LOG1 NACT NBNK_A NBNK_B NCADDR_A[0]
+  NCADDR_A[1] NCADDR_B[0] NCADDR_B[1] NCE_A NCE_B NCLK_CTL_A NCLK_CTL_B
+  NC_PGEN NC_RET2N NDFTCRE1 NDFTCRE2 NFAST_ACT NGWE_A NGWE_B NGWE_WT_A
+  NGWE_WT_B NHDR_WL_A NHDR_WL_B NIRET NRDTA NRDTB NRETNVT NRET_A
+  NRET_ACT_FT1_A NRET_ACT_FT2_A NRET_B NTE_A NTE_B NWRA_MA NWRB_MA NWTE_A
+  NWTE_B NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] ONE_C PENA
+  PENB PENSIA PENSIB PENSOA PENSOB PGEN_N PSOA[0] PSOA[1] PSOB[0] PSOB[1]
+  QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11]
+  QA[12] QA[13] QA[14] QA[15] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7]
+  QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] RAA[0] RAA[1] RAA[2]
+  RAA[3] RAA[4] RAA[5] RAA[6] RAA[7] RAA[8] RAB[0] RAB[1] RAB[2] RAB[3]
+  RAB[4] RAB[5] RAB[6] RAB[7] RAB[8] RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4]
+  RAYA[5] RAYA[6] RAYA[7] RAYA[8] RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4]
+  RAYB[5] RAYB[6] RAYB[7] RAYB[8] RDTA RDTB RET1N RET1N_BUF RET_A RET_B SEA
+  SEB SOA[0] SOA[1] SOB[0] SOB[1] TCAA[0] TCAA[1] TCAA[2] TCAA[3] TCAB[0]
+  TCAB[1] TCAB[2] TCAB[3] TCENA TCENB TDA[0] TDA[1] TDA[2] TDA[3] TDA[4]
+  TDA[5] TDA[6] TDA[7] TDA[8] TDA[9] TDA[10] TDA[11] TDA[12] TDA[13] TDA[14]
+  TDA[15] TDB[0] TDB[1] TDB[2] TDB[3] TDB[4] TDB[5] TDB[6] TDB[7] TDB[8]
+  TDB[9] TDB[10] TDB[11] TDB[12] TDB[13] TDB[14] TDB[15] TENA TENB TGWENA
+  TGWENB TPENA TPENB TRAA[0] TRAA[1] TRAA[2] TRAA[3] TRAA[4] TRAA[5] TRAA[6]
+  TRAA[7] TRAA[8] TRAB[0] TRAB[1] TRAB[2] TRAB[3] TRAB[4] TRAB[5] TRAB[6]
+  TRAB[7] TRAB[8] TWENA[0] TWENA[1] TWENA[2] TWENA[3] TWENA[4] TWENA[5]
+  TWENA[6] TWENA[7] TWENA[8] TWENA[9] TWENA[10] TWENA[11] TWENA[12] TWENA[13]
+  TWENA[14] TWENA[15] TWENB[0] TWENB[1] TWENB[2] TWENB[3] TWENB[4] TWENB[5]
+  TWENB[6] TWENB[7] TWENB[8] TWENB[9] TWENB[10] TWENB[11] TWENB[12] TWENB[13]
+  TWENB[14] TWENB[15] VDDCE VDDPE VNWC VNWP VPW VSS VSSE WENA[0] WENA[1]
+  WENA[2] WENA[3] WENA[4] WENA[5] WENA[6] WENA[7] WENA[8] WENA[9] WENA[10]
+  WENA[11] WENA[12] WENA[13] WENA[14] WENA[15] WENB[0] WENB[1] WENB[2]
+  WENB[3] WENB[4] WENB[5] WENB[6] WENB[7] WENB[8] WENB[9] WENB[10] WENB[11]
+  WENB[12] WENB[13] WENB[14] WENB[15] WENYA[0] WENYA[1] WENYA[2] WENYA[3]
+  WENYA[4] WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11]
+  WENYA[12] WENYA[13] WENYA[14] WENYA[15] WENYB[0] WENYB[1] WENYB[2] WENYB[3]
+  WENYB[4] WENYB[5] WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11]
+  WENYB[12] WENYB[13] WENYB[14] WENYB[15] WT ZERO_C
** SRAMdpw64d256CNTL_1V: 1921 flat devices **
X_MI100.I0.MXNA1 I100.NET032 I100.NET021 I100.I0.N1 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MI100.I0.MXNA2 I100.I0.N1 CRE2 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI100.I0.MXPA1 I100.NET032 I100.NET021 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI100.I0.MXPA2 I100.NET032 CRE2 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI100.I13.MXNA1 NDFTCRE2 I100.NET032 VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI100.I13.MXPA1 NDFTCRE2 I100.NET032 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI100.I14.MXNA1 I100.NET021 DFTRAMBYP VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI100.I14.MXPA1 I100.NET021 DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI100.I48.MXNA1 I100.NET28 I100.NET021 I100.I48.N1 VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MI100.I48.MXNA2 I100.I48.N1 CRE1 VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI100.I48.MXPA1 I100.NET28 I100.NET021 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI100.I48.MXPA2 I100.NET28 CRE1 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI100.I49.MXNA1 NDFTCRE1 I100.NET28 VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI100.I49.MXPA1 NDFTCRE1 I100.NET28 VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI101_0.MXN0 LOG0_CRE2 I101_0.NODEB VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI101_0.MXN1 I101_0.NODEA I101_0.NODEA VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI101_0.MXN2 I101_0.NODEA I101_0.NODEB VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI101_0.MXP0 NET1278[1] I101_0.NODEA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI101_0.MXP1 I101_0.NODEB I101_0.NODEA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI101_1.MXN0 LOG0_CRE1 I101_1.NODEB VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI101_1.MXN1 I101_1.NODEA I101_1.NODEA VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI101_1.MXN2 I101_1.NODEA I101_1.NODEB VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI101_1.MXP0 NET1278[0] I101_1.NODEA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI101_1.MXP1 I101_1.NODEB I101_1.NODEA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MI103.I103.MXN0 LOGIC0 I103.I103.NODEB VSS VPW N11LL_CKT W=0.74U L=0.04U
X_MI103.I103.MXN1 I103.I103.NODEA I103.I103.NODEA VSS VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI103.I103.MXN2 I103.I103.NODEA I103.I103.NODEB VSS VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI103.I103.MXP1 I103.I103.NODEB I103.I103.NODEA VDDPE VNWP P11LL_CKT
+  W=0.555U L=0.04U
X_MI103.I103.MXP4 LOGIC1 I103.I103.NODEA VDDPE VNWP P11LL_CKT W=2.95U L=0.04U
X_MI88_0.I48.MXNA1 I88_0.NET28 SEL_SI_B VSS VPW N11LL_CKT W=0.995U L=0.04U
X_MI88_0.I48.MXPA1 I88_0.NET28 SEL_SI_B VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MI88_0.I49.MXNA1 BSEL_SI_B I88_0.NET28 VSS VPW N11LL_CKT W=7.2U L=0.04U
X_MI88_0.I49.MXPA1 BSEL_SI_B I88_0.NET28 VDDPE VNWP P11LL_CKT W=10.64U L=0.04U
X_MI88_1.I48.MXNA1 I88_1.NET28 SEL_TD_B VSS VPW N11LL_CKT W=0.995U L=0.04U
X_MI88_1.I48.MXPA1 I88_1.NET28 SEL_TD_B VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MI88_1.I49.MXNA1 BSEL_TD_B I88_1.NET28 VSS VPW N11LL_CKT W=7.2U L=0.04U
X_MI88_1.I49.MXPA1 BSEL_TD_B I88_1.NET28 VDDPE VNWP P11LL_CKT W=10.64U L=0.04U
X_MI88_2.I48.MXNA1 I88_2.NET28 SEL_D_B VSS VPW N11LL_CKT W=0.995U L=0.04U
X_MI88_2.I48.MXPA1 I88_2.NET28 SEL_D_B VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MI88_2.I49.MXNA1 BSEL_D_B I88_2.NET28 VSS VPW N11LL_CKT W=7.2U L=0.04U
X_MI88_2.I49.MXPA1 BSEL_D_B I88_2.NET28 VDDPE VNWP P11LL_CKT W=10.64U L=0.04U
X_MI88_3.I48.MXNA1 I88_3.NET28 SEL_SI_A VSS VPW N11LL_CKT W=0.995U L=0.04U
X_MI88_3.I48.MXPA1 I88_3.NET28 SEL_SI_A VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MI88_3.I49.MXNA1 BSEL_SI_A I88_3.NET28 VSS VPW N11LL_CKT W=7.2U L=0.04U
X_MI88_3.I49.MXPA1 BSEL_SI_A I88_3.NET28 VDDPE VNWP P11LL_CKT W=10.64U L=0.04U
X_MI88_4.I48.MXNA1 I88_4.NET28 SEL_TD_A VSS VPW N11LL_CKT W=0.995U L=0.04U
X_MI88_4.I48.MXPA1 I88_4.NET28 SEL_TD_A VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MI88_4.I49.MXNA1 BSEL_TD_A I88_4.NET28 VSS VPW N11LL_CKT W=7.2U L=0.04U
X_MI88_4.I49.MXPA1 BSEL_TD_A I88_4.NET28 VDDPE VNWP P11LL_CKT W=10.64U L=0.04U
X_MI88_5.I48.MXNA1 I88_5.NET28 SEL_D_A VSS VPW N11LL_CKT W=0.995U L=0.04U
X_MI88_5.I48.MXPA1 I88_5.NET28 SEL_D_A VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MI88_5.I49.MXNA1 BSEL_D_A I88_5.NET28 VSS VPW N11LL_CKT W=7.2U L=0.04U
X_MI88_5.I49.MXPA1 BSEL_D_A I88_5.NET28 VDDPE VNWP P11LL_CKT W=10.64U L=0.04U
X_MIcntl_dp_1va.I2.MXNA1 NTE_A ICNTL_DP_1VA.NET87 VSS VPW N11LL_CKT W=3.81U
+  L=0.04U
X_MIcntl_dp_1va.I2.MXPA1 NTE_A ICNTL_DP_1VA.NET87 VDDPE VNWP P11LL_CKT W=5.76U
+  L=0.04U
X_MIcntl_dp_1va.I48.MXNA1 ICNTL_DP_1VA.NET75 DFTRAMBYP_P2_A VSS VPW N11LL_CKT
+  W=0.8U L=0.04U
X_MIcntl_dp_1va.I48.MXPA1 ICNTL_DP_1VA.NET75 DFTRAMBYP_P2_A VDDPE VNWP
+  P11LL_CKT W=1.15U L=0.04U
X_MIcntl_dp_1va.I49.MXNA1 BDFTRAMBYP_A ICNTL_DP_1VA.NET75 VSS VPW N11LL_CKT
+  W=1.92U L=0.04U
X_MIcntl_dp_1va.I49.MXPA1 BDFTRAMBYP_A ICNTL_DP_1VA.NET75 VDDPE VNWP P11LL_CKT
+  W=3.84U L=0.04U
X_MIcntl_dp_1va.I74.I2.MXNA1 NBNK_A RADDR_A[8] VSS VPW N11LL_CKT W=3.92U
+  L=0.04U
X_MIcntl_dp_1va.I74.I2.MXPA1 NBNK_A RADDR_A[8] VDDPE VNWP P11LL_CKT W=7.52U
+  L=0.04U
X_MIcntl_dp_1va.I82.MXNA1 ICNTL_DP_1VA.NET87 TENA VSS VPW N11LL_CKT W=0.77U
+  L=0.04U
X_MIcntl_dp_1va.I82.MXPA1 ICNTL_DP_1VA.NET87 TENA VDDPE VNWP P11LL_CKT W=1.15U
+  L=0.04U
X_MIcntl_dp_1va.Ipdec2.I16_0.MXNA1 ICNTL_DP_1VA.IPDEC2.ADDR[0] NRADDR_A[3] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec2.I16_0.MXPA1 ICNTL_DP_1VA.IPDEC2.ADDR[0] NRADDR_A[3]
+  VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec2.I16_1.MXNA1 ICNTL_DP_1VA.IPDEC2.ADDR[1] NRADDR_A[4] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec2.I16_1.MXPA1 ICNTL_DP_1VA.IPDEC2.ADDR[1] NRADDR_A[4]
+  VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec2.I16_2.MXNA1 ICNTL_DP_1VA.IPDEC2.ADDR[2] NRADDR_A[5] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec2.I16_2.MXPA1 ICNTL_DP_1VA.IPDEC2.ADDR[2] NRADDR_A[5]
+  VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_0.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_0.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_0.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_0.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I19.MXNA1 NXPDEC2_A[0]
+  ICNTL_DP_1VA.IPDEC2.IAND_0.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I19.MXPA1 NXPDEC2_A[0]
+  ICNTL_DP_1VA.IPDEC2.IAND_0.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_0.DEC_N
+  NRADDR_A[5] ICNTL_DP_1VA.IPDEC2.IAND_0.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_0.I9.N2
+  NRADDR_A[4] ICNTL_DP_1VA.IPDEC2.IAND_0.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_0.I9.N1
+  NRADDR_A[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_0.DEC_N
+  NRADDR_A[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_0.DEC_N
+  NRADDR_A[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_0.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_0.DEC_N
+  NRADDR_A[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_1.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_1.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_1.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_1.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I19.MXNA1 NXPDEC2_A[1]
+  ICNTL_DP_1VA.IPDEC2.IAND_1.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I19.MXPA1 NXPDEC2_A[1]
+  ICNTL_DP_1VA.IPDEC2.IAND_1.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_1.DEC_N
+  NRADDR_A[5] ICNTL_DP_1VA.IPDEC2.IAND_1.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_1.I9.N2
+  NRADDR_A[4] ICNTL_DP_1VA.IPDEC2.IAND_1.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_1.I9.N1
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_1.DEC_N
+  NRADDR_A[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_1.DEC_N
+  NRADDR_A[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_1.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_1.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_2.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_2.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_2.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_2.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I19.MXNA1 NXPDEC2_A[2]
+  ICNTL_DP_1VA.IPDEC2.IAND_2.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I19.MXPA1 NXPDEC2_A[2]
+  ICNTL_DP_1VA.IPDEC2.IAND_2.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_2.DEC_N
+  NRADDR_A[5] ICNTL_DP_1VA.IPDEC2.IAND_2.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_2.I9.N2
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] ICNTL_DP_1VA.IPDEC2.IAND_2.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_2.I9.N1
+  NRADDR_A[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_2.DEC_N
+  NRADDR_A[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_2.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_2.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_2.DEC_N
+  NRADDR_A[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_3.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_3.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_3.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_3.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I19.MXNA1 NXPDEC2_A[3]
+  ICNTL_DP_1VA.IPDEC2.IAND_3.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I19.MXPA1 NXPDEC2_A[3]
+  ICNTL_DP_1VA.IPDEC2.IAND_3.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_3.DEC_N
+  NRADDR_A[5] ICNTL_DP_1VA.IPDEC2.IAND_3.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_3.I9.N2
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] ICNTL_DP_1VA.IPDEC2.IAND_3.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_3.I9.N1
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_3.DEC_N
+  NRADDR_A[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_3.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_3.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_3.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_4.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_4.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_4.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_4.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I19.MXNA1 NXPDEC2_A[4]
+  ICNTL_DP_1VA.IPDEC2.IAND_4.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I19.MXPA1 NXPDEC2_A[4]
+  ICNTL_DP_1VA.IPDEC2.IAND_4.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_4.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] ICNTL_DP_1VA.IPDEC2.IAND_4.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_4.I9.N2
+  NRADDR_A[4] ICNTL_DP_1VA.IPDEC2.IAND_4.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_4.I9.N1
+  NRADDR_A[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_4.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_4.DEC_N
+  NRADDR_A[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_4.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_4.DEC_N
+  NRADDR_A[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_5.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_5.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_5.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_5.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I19.MXNA1 NXPDEC2_A[5]
+  ICNTL_DP_1VA.IPDEC2.IAND_5.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I19.MXPA1 NXPDEC2_A[5]
+  ICNTL_DP_1VA.IPDEC2.IAND_5.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_5.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] ICNTL_DP_1VA.IPDEC2.IAND_5.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_5.I9.N2
+  NRADDR_A[4] ICNTL_DP_1VA.IPDEC2.IAND_5.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_5.I9.N1
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_5.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_5.DEC_N
+  NRADDR_A[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_5.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_5.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_6.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_6.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_6.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_6.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I19.MXNA1 NXPDEC2_A[6]
+  ICNTL_DP_1VA.IPDEC2.IAND_6.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I19.MXPA1 NXPDEC2_A[6]
+  ICNTL_DP_1VA.IPDEC2.IAND_6.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_6.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] ICNTL_DP_1VA.IPDEC2.IAND_6.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_6.I9.N2
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] ICNTL_DP_1VA.IPDEC2.IAND_6.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_6.I9.N1
+  NRADDR_A[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_6.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_6.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_6.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_6.DEC_N
+  NRADDR_A[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I17.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_7.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_7.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I17.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_7.DEC
+  ICNTL_DP_1VA.IPDEC2.IAND_7.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I19.MXNA1 NXPDEC2_A[7]
+  ICNTL_DP_1VA.IPDEC2.IAND_7.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I19.MXPA1 NXPDEC2_A[7]
+  ICNTL_DP_1VA.IPDEC2.IAND_7.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I9.MXNA1 ICNTL_DP_1VA.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] ICNTL_DP_1VA.IPDEC2.IAND_7.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I9.MXNA2 ICNTL_DP_1VA.IPDEC2.IAND_7.I9.N2
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] ICNTL_DP_1VA.IPDEC2.IAND_7.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I9.MXNA3 ICNTL_DP_1VA.IPDEC2.IAND_7.I9.N1
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I9.MXPA1 ICNTL_DP_1VA.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I9.MXPA2 ICNTL_DP_1VA.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec2.Iand_7.I9.MXPA3 ICNTL_DP_1VA.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VA.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.I16_0.MXNA1 ICNTL_DP_1VA.IPDEC3.ADDR[0] NRADDR_A[6] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec3.I16_0.MXPA1 ICNTL_DP_1VA.IPDEC3.ADDR[0] NRADDR_A[6]
+  VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec3.I16_1.MXNA1 ICNTL_DP_1VA.IPDEC3.ADDR[1] NRADDR_A[7] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec3.I16_1.MXPA1 ICNTL_DP_1VA.IPDEC3.ADDR[1] NRADDR_A[7]
+  VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I17.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_0.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_0.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I17.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_0.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_0.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I19.MXNA1 NXPDEC3_A[0]
+  ICNTL_DP_1VA.IPDEC3.IAND_0.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I19.MXPA1 NXPDEC3_A[0]
+  ICNTL_DP_1VA.IPDEC3.IAND_0.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I9.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_0.DEC_N
+  NRADDR_A[6] ICNTL_DP_1VA.IPDEC3.IAND_0.I9.N1 VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I9.MXNA2 ICNTL_DP_1VA.IPDEC3.IAND_0.I9.N1
+  NRADDR_A[7] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I9.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_0.DEC_N
+  NRADDR_A[6] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_0.I9.MXPA2 ICNTL_DP_1VA.IPDEC3.IAND_0.DEC_N
+  NRADDR_A[7] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I17.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_1.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_1.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I17.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_1.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_1.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I19.MXNA1 NXPDEC3_A[1]
+  ICNTL_DP_1VA.IPDEC3.IAND_1.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I19.MXPA1 NXPDEC3_A[1]
+  ICNTL_DP_1VA.IPDEC3.IAND_1.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I9.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_1.DEC_N
+  ICNTL_DP_1VA.IPDEC3.ADDR[0] ICNTL_DP_1VA.IPDEC3.IAND_1.I9.N1 VPW N11LL_CKT
+  W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I9.MXNA2 ICNTL_DP_1VA.IPDEC3.IAND_1.I9.N1
+  NRADDR_A[7] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I9.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_1.DEC_N
+  ICNTL_DP_1VA.IPDEC3.ADDR[0] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_1.I9.MXPA2 ICNTL_DP_1VA.IPDEC3.IAND_1.DEC_N
+  NRADDR_A[7] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I17.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_2.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_2.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I17.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_2.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_2.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I19.MXNA1 NXPDEC3_A[2]
+  ICNTL_DP_1VA.IPDEC3.IAND_2.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I19.MXPA1 NXPDEC3_A[2]
+  ICNTL_DP_1VA.IPDEC3.IAND_2.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I9.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_2.DEC_N
+  NRADDR_A[6] ICNTL_DP_1VA.IPDEC3.IAND_2.I9.N1 VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I9.MXNA2 ICNTL_DP_1VA.IPDEC3.IAND_2.I9.N1
+  ICNTL_DP_1VA.IPDEC3.ADDR[1] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I9.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_2.DEC_N
+  NRADDR_A[6] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_2.I9.MXPA2 ICNTL_DP_1VA.IPDEC3.IAND_2.DEC_N
+  ICNTL_DP_1VA.IPDEC3.ADDR[1] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I17.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_3.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_3.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I17.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_3.DEC
+  ICNTL_DP_1VA.IPDEC3.IAND_3.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I19.MXNA1 NXPDEC3_A[3]
+  ICNTL_DP_1VA.IPDEC3.IAND_3.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I19.MXPA1 NXPDEC3_A[3]
+  ICNTL_DP_1VA.IPDEC3.IAND_3.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I9.MXNA1 ICNTL_DP_1VA.IPDEC3.IAND_3.DEC_N
+  ICNTL_DP_1VA.IPDEC3.ADDR[0] ICNTL_DP_1VA.IPDEC3.IAND_3.I9.N1 VPW N11LL_CKT
+  W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I9.MXNA2 ICNTL_DP_1VA.IPDEC3.IAND_3.I9.N1
+  ICNTL_DP_1VA.IPDEC3.ADDR[1] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I9.MXPA1 ICNTL_DP_1VA.IPDEC3.IAND_3.DEC_N
+  ICNTL_DP_1VA.IPDEC3.ADDR[0] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1va.Ipdec3.Iand_3.I9.MXPA2 ICNTL_DP_1VA.IPDEC3.IAND_3.DEC_N
+  ICNTL_DP_1VA.IPDEC3.ADDR[1] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.I2.MXNA1 NTE_B ICNTL_DP_1VB.NET87 VSS VPW N11LL_CKT W=3.81U
+  L=0.04U
X_MIcntl_dp_1vb.I2.MXPA1 NTE_B ICNTL_DP_1VB.NET87 VDDPE VNWP P11LL_CKT W=5.76U
+  L=0.04U
X_MIcntl_dp_1vb.I48.MXNA1 ICNTL_DP_1VB.NET75 DFTRAMBYP_P2_B VSS VPW N11LL_CKT
+  W=0.8U L=0.04U
X_MIcntl_dp_1vb.I48.MXPA1 ICNTL_DP_1VB.NET75 DFTRAMBYP_P2_B VDDPE VNWP
+  P11LL_CKT W=1.15U L=0.04U
X_MIcntl_dp_1vb.I49.MXNA1 BDFTRAMBYP_B ICNTL_DP_1VB.NET75 VSS VPW N11LL_CKT
+  W=1.92U L=0.04U
X_MIcntl_dp_1vb.I49.MXPA1 BDFTRAMBYP_B ICNTL_DP_1VB.NET75 VDDPE VNWP P11LL_CKT
+  W=3.84U L=0.04U
X_MIcntl_dp_1vb.I74.I2.MXNA1 NBNK_B RADDR_B[8] VSS VPW N11LL_CKT W=3.92U
+  L=0.04U
X_MIcntl_dp_1vb.I74.I2.MXPA1 NBNK_B RADDR_B[8] VDDPE VNWP P11LL_CKT W=7.52U
+  L=0.04U
X_MIcntl_dp_1vb.I82.MXNA1 ICNTL_DP_1VB.NET87 TENB VSS VPW N11LL_CKT W=0.77U
+  L=0.04U
X_MIcntl_dp_1vb.I82.MXPA1 ICNTL_DP_1VB.NET87 TENB VDDPE VNWP P11LL_CKT W=1.15U
+  L=0.04U
X_MIcntl_dp_1vb.Ipdec2.I16_0.MXNA1 ICNTL_DP_1VB.IPDEC2.ADDR[0] NRADDR_B[3] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.I16_0.MXPA1 ICNTL_DP_1VB.IPDEC2.ADDR[0] NRADDR_B[3]
+  VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.I16_1.MXNA1 ICNTL_DP_1VB.IPDEC2.ADDR[1] NRADDR_B[4] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.I16_1.MXPA1 ICNTL_DP_1VB.IPDEC2.ADDR[1] NRADDR_B[4]
+  VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.I16_2.MXNA1 ICNTL_DP_1VB.IPDEC2.ADDR[2] NRADDR_B[5] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.I16_2.MXPA1 ICNTL_DP_1VB.IPDEC2.ADDR[2] NRADDR_B[5]
+  VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_0.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_0.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_0.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_0.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I19.MXNA1 NXPDEC2_B[0]
+  ICNTL_DP_1VB.IPDEC2.IAND_0.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I19.MXPA1 NXPDEC2_B[0]
+  ICNTL_DP_1VB.IPDEC2.IAND_0.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_0.DEC_N
+  NRADDR_B[5] ICNTL_DP_1VB.IPDEC2.IAND_0.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_0.I9.N2
+  NRADDR_B[4] ICNTL_DP_1VB.IPDEC2.IAND_0.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_0.I9.N1
+  NRADDR_B[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_0.DEC_N
+  NRADDR_B[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_0.DEC_N
+  NRADDR_B[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_0.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_0.DEC_N
+  NRADDR_B[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_1.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_1.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_1.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_1.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I19.MXNA1 NXPDEC2_B[1]
+  ICNTL_DP_1VB.IPDEC2.IAND_1.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I19.MXPA1 NXPDEC2_B[1]
+  ICNTL_DP_1VB.IPDEC2.IAND_1.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_1.DEC_N
+  NRADDR_B[5] ICNTL_DP_1VB.IPDEC2.IAND_1.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_1.I9.N2
+  NRADDR_B[4] ICNTL_DP_1VB.IPDEC2.IAND_1.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_1.I9.N1
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_1.DEC_N
+  NRADDR_B[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_1.DEC_N
+  NRADDR_B[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_1.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_1.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_2.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_2.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_2.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_2.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I19.MXNA1 NXPDEC2_B[2]
+  ICNTL_DP_1VB.IPDEC2.IAND_2.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I19.MXPA1 NXPDEC2_B[2]
+  ICNTL_DP_1VB.IPDEC2.IAND_2.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_2.DEC_N
+  NRADDR_B[5] ICNTL_DP_1VB.IPDEC2.IAND_2.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_2.I9.N2
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] ICNTL_DP_1VB.IPDEC2.IAND_2.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_2.I9.N1
+  NRADDR_B[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_2.DEC_N
+  NRADDR_B[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_2.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_2.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_2.DEC_N
+  NRADDR_B[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_3.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_3.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_3.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_3.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I19.MXNA1 NXPDEC2_B[3]
+  ICNTL_DP_1VB.IPDEC2.IAND_3.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I19.MXPA1 NXPDEC2_B[3]
+  ICNTL_DP_1VB.IPDEC2.IAND_3.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_3.DEC_N
+  NRADDR_B[5] ICNTL_DP_1VB.IPDEC2.IAND_3.I9.N2 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_3.I9.N2
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] ICNTL_DP_1VB.IPDEC2.IAND_3.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_3.I9.N1
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_3.DEC_N
+  NRADDR_B[5] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_3.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_3.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_3.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_4.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_4.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_4.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_4.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I19.MXNA1 NXPDEC2_B[4]
+  ICNTL_DP_1VB.IPDEC2.IAND_4.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I19.MXPA1 NXPDEC2_B[4]
+  ICNTL_DP_1VB.IPDEC2.IAND_4.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_4.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] ICNTL_DP_1VB.IPDEC2.IAND_4.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_4.I9.N2
+  NRADDR_B[4] ICNTL_DP_1VB.IPDEC2.IAND_4.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_4.I9.N1
+  NRADDR_B[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_4.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_4.DEC_N
+  NRADDR_B[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_4.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_4.DEC_N
+  NRADDR_B[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_5.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_5.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_5.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_5.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I19.MXNA1 NXPDEC2_B[5]
+  ICNTL_DP_1VB.IPDEC2.IAND_5.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I19.MXPA1 NXPDEC2_B[5]
+  ICNTL_DP_1VB.IPDEC2.IAND_5.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_5.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] ICNTL_DP_1VB.IPDEC2.IAND_5.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_5.I9.N2
+  NRADDR_B[4] ICNTL_DP_1VB.IPDEC2.IAND_5.I9.N1 VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_5.I9.N1
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_5.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_5.DEC_N
+  NRADDR_B[4] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_5.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_5.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_6.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_6.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_6.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_6.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I19.MXNA1 NXPDEC2_B[6]
+  ICNTL_DP_1VB.IPDEC2.IAND_6.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I19.MXPA1 NXPDEC2_B[6]
+  ICNTL_DP_1VB.IPDEC2.IAND_6.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_6.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] ICNTL_DP_1VB.IPDEC2.IAND_6.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_6.I9.N2
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] ICNTL_DP_1VB.IPDEC2.IAND_6.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_6.I9.N1
+  NRADDR_B[3] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_6.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_6.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_6.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_6.DEC_N
+  NRADDR_B[3] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I17.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_7.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_7.DEC_N VSS VPW N11LL_CKT W=1U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I17.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_7.DEC
+  ICNTL_DP_1VB.IPDEC2.IAND_7.DEC_N VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I19.MXNA1 NXPDEC2_B[7]
+  ICNTL_DP_1VB.IPDEC2.IAND_7.DEC VSS VPW N11LL_CKT W=3.84U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I19.MXPA1 NXPDEC2_B[7]
+  ICNTL_DP_1VB.IPDEC2.IAND_7.DEC VDDPE VNWP P11LL_CKT W=7.48U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I9.MXNA1 ICNTL_DP_1VB.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] ICNTL_DP_1VB.IPDEC2.IAND_7.I9.N2 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I9.MXNA2 ICNTL_DP_1VB.IPDEC2.IAND_7.I9.N2
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] ICNTL_DP_1VB.IPDEC2.IAND_7.I9.N1 VPW N11LL_CKT
+  W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I9.MXNA3 ICNTL_DP_1VB.IPDEC2.IAND_7.I9.N1
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VSS VPW N11LL_CKT W=0.895U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I9.MXPA1 ICNTL_DP_1VB.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[2] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I9.MXPA2 ICNTL_DP_1VB.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[1] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec2.Iand_7.I9.MXPA3 ICNTL_DP_1VB.IPDEC2.IAND_7.DEC_N
+  ICNTL_DP_1VB.IPDEC2.ADDR[0] VDDPE VNWP P11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.I16_0.MXNA1 ICNTL_DP_1VB.IPDEC3.ADDR[0] NRADDR_B[6] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.I16_0.MXPA1 ICNTL_DP_1VB.IPDEC3.ADDR[0] NRADDR_B[6]
+  VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.I16_1.MXNA1 ICNTL_DP_1VB.IPDEC3.ADDR[1] NRADDR_B[7] VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.I16_1.MXPA1 ICNTL_DP_1VB.IPDEC3.ADDR[1] NRADDR_B[7]
+  VDDPE VNWP P11LL_CKT W=1.92U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I17.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_0.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_0.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I17.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_0.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_0.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I19.MXNA1 NXPDEC3_B[0]
+  ICNTL_DP_1VB.IPDEC3.IAND_0.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I19.MXPA1 NXPDEC3_B[0]
+  ICNTL_DP_1VB.IPDEC3.IAND_0.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I9.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_0.DEC_N
+  NRADDR_B[6] ICNTL_DP_1VB.IPDEC3.IAND_0.I9.N1 VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I9.MXNA2 ICNTL_DP_1VB.IPDEC3.IAND_0.I9.N1
+  NRADDR_B[7] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I9.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_0.DEC_N
+  NRADDR_B[6] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_0.I9.MXPA2 ICNTL_DP_1VB.IPDEC3.IAND_0.DEC_N
+  NRADDR_B[7] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I17.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_1.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_1.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I17.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_1.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_1.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I19.MXNA1 NXPDEC3_B[1]
+  ICNTL_DP_1VB.IPDEC3.IAND_1.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I19.MXPA1 NXPDEC3_B[1]
+  ICNTL_DP_1VB.IPDEC3.IAND_1.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I9.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_1.DEC_N
+  ICNTL_DP_1VB.IPDEC3.ADDR[0] ICNTL_DP_1VB.IPDEC3.IAND_1.I9.N1 VPW N11LL_CKT
+  W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I9.MXNA2 ICNTL_DP_1VB.IPDEC3.IAND_1.I9.N1
+  NRADDR_B[7] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I9.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_1.DEC_N
+  ICNTL_DP_1VB.IPDEC3.ADDR[0] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_1.I9.MXPA2 ICNTL_DP_1VB.IPDEC3.IAND_1.DEC_N
+  NRADDR_B[7] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I17.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_2.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_2.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I17.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_2.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_2.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I19.MXNA1 NXPDEC3_B[2]
+  ICNTL_DP_1VB.IPDEC3.IAND_2.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I19.MXPA1 NXPDEC3_B[2]
+  ICNTL_DP_1VB.IPDEC3.IAND_2.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I9.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_2.DEC_N
+  NRADDR_B[6] ICNTL_DP_1VB.IPDEC3.IAND_2.I9.N1 VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I9.MXNA2 ICNTL_DP_1VB.IPDEC3.IAND_2.I9.N1
+  ICNTL_DP_1VB.IPDEC3.ADDR[1] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I9.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_2.DEC_N
+  NRADDR_B[6] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_2.I9.MXPA2 ICNTL_DP_1VB.IPDEC3.IAND_2.DEC_N
+  ICNTL_DP_1VB.IPDEC3.ADDR[1] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I17.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_3.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_3.DEC_N VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I17.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_3.DEC
+  ICNTL_DP_1VB.IPDEC3.IAND_3.DEC_N VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I19.MXNA1 NXPDEC3_B[3]
+  ICNTL_DP_1VB.IPDEC3.IAND_3.DEC VSS VPW N11LL_CKT W=3.74U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I19.MXPA1 NXPDEC3_B[3]
+  ICNTL_DP_1VB.IPDEC3.IAND_3.DEC VDDPE VNWP P11LL_CKT W=7.58U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I9.MXNA1 ICNTL_DP_1VB.IPDEC3.IAND_3.DEC_N
+  ICNTL_DP_1VB.IPDEC3.ADDR[0] ICNTL_DP_1VB.IPDEC3.IAND_3.I9.N1 VPW N11LL_CKT
+  W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I9.MXNA2 ICNTL_DP_1VB.IPDEC3.IAND_3.I9.N1
+  ICNTL_DP_1VB.IPDEC3.ADDR[1] VSS VPW N11LL_CKT W=0.575U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I9.MXPA1 ICNTL_DP_1VB.IPDEC3.IAND_3.DEC_N
+  ICNTL_DP_1VB.IPDEC3.ADDR[0] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_dp_1vb.Ipdec3.Iand_3.I9.MXPA2 ICNTL_DP_1VB.IPDEC3.IAND_3.DEC_N
+  ICNTL_DP_1VB.IPDEC3.ADDR[1] VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIcntl_mid_1v.I103.I2.MXNA1 ACTCLMP_A ICNTL_MID_1V.I103.NA VSSE VPW
+  N11LL_CKT W=1.8U L=0.04U
X_MIcntl_mid_1v.I103.I2.MXPA1 ACTCLMP_A ICNTL_MID_1V.I103.NA VDDPE VNWP
+  P11LL_CKT W=3.56U L=0.04U
X_MIcntl_mid_1v.I103.I5.MXNA1 ICNTL_MID_1V.I103.NA ACTCLMP VSSE VPW N11LL_CKT
+  W=0.3U L=0.04U
X_MIcntl_mid_1v.I103.I5.MXPA1 ICNTL_MID_1V.I103.NA ACTCLMP VDDPE VNWP
+  P11LL_CKT W=0.595U L=0.04U
X_MIcntl_mid_1v.I104.I2.MXNA1 ACTCLMP_B ICNTL_MID_1V.I104.NA VSSE VPW
+  N11LL_CKT W=1.8U L=0.04U
X_MIcntl_mid_1v.I104.I2.MXPA1 ACTCLMP_B ICNTL_MID_1V.I104.NA VDDPE VNWP
+  P11LL_CKT W=3.56U L=0.04U
X_MIcntl_mid_1v.I104.I5.MXNA1 ICNTL_MID_1V.I104.NA ACTCLMP VSSE VPW N11LL_CKT
+  W=0.3U L=0.04U
X_MIcntl_mid_1v.I104.I5.MXPA1 ICNTL_MID_1V.I104.NA ACTCLMP VDDPE VNWP
+  P11LL_CKT W=0.595U L=0.04U
X_MIcntl_mid_1v.I107.MXNA1 ICNTL_MID_1V.CLK_CTL_B NCLK_CTL_B VSS VPW N11LL_CKT
+  W=0.135U L=0.04U
X_MIcntl_mid_1v.I107.MXPA1 ICNTL_MID_1V.CLK_CTL_B NCLK_CTL_B VDDPE VNWP
+  P11LL_CKT W=0.2U L=0.04U
X_MIcntl_mid_1v.I32_0.MXNA1 ICNTL_MID_1V.CE_B NCE_B VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_MIcntl_mid_1v.I32_0.MXPA1 ICNTL_MID_1V.CE_B NCE_B VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcntl_mid_1v.I32_1.MXNA1 ICNTL_MID_1V.CE_A NCE_A VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_MIcntl_mid_1v.I32_1.MXPA1 ICNTL_MID_1V.CE_A NCE_A VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcntl_mid_1v.I49.MXNA1 ICNTL_MID_1V.CLK_CTL_A NCLK_CTL_A VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIcntl_mid_1v.I49.MXPA1 ICNTL_MID_1V.CLK_CTL_A NCLK_CTL_A VDDPE VNWP
+  P11LL_CKT W=0.2U L=0.04U
X_MIcntl_mid_1v.I56_0.I2.MXNA1 ICNTL_MID_1V.BRET_ACT_FT2_A NACT VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_MIcntl_mid_1v.I56_0.I2.MXPA1 ICNTL_MID_1V.BRET_ACT_FT2_A NACT VDDCE VNWC
+  P11LL_CKT W=1.42U L=0.04U
X_MIcntl_mid_1v.I56_1.I2.MXNA1 ICNTL_MID_1V.BRET_ACT_FT1_A NRETNVT VSSE VPW
+  N11LL_CKT W=0.71U L=0.04U
X_MIcntl_mid_1v.I56_1.I2.MXPA1 ICNTL_MID_1V.BRET_ACT_FT1_A NRETNVT VDDCE VNWC
+  P11LL_CKT W=1.42U L=0.04U
X_MIcntl_mid_1v.I72_0.I2.MXNA1 EMAWA_DEP2[0] ICNTL_MID_1V.NEMAWA_DEP1[0] VSS
+  VPW N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I72_0.I2.MXPA1 EMAWA_DEP2[0] ICNTL_MID_1V.NEMAWA_DEP1[0] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I72_1.I2.MXNA1 EMAWA_DEP2[1] ICNTL_MID_1V.NEMAWA_DEP1[1] VSS
+  VPW N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I72_1.I2.MXPA1 EMAWA_DEP2[1] ICNTL_MID_1V.NEMAWA_DEP1[1] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I72_2.I2.MXNA1 EMAA_DEP2[0] ICNTL_MID_1V.NEMAA_DEP1[0] VSS VPW
+  N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I72_2.I2.MXPA1 EMAA_DEP2[0] ICNTL_MID_1V.NEMAA_DEP1[0] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I72_3.I2.MXNA1 EMAA_DEP2[1] ICNTL_MID_1V.NEMAA_DEP1[1] VSS VPW
+  N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I72_3.I2.MXPA1 EMAA_DEP2[1] ICNTL_MID_1V.NEMAA_DEP1[1] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I72_4.I2.MXNA1 EMAA_DEP2[2] ICNTL_MID_1V.NEMAA_DEP1[2] VSS VPW
+  N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I72_4.I2.MXPA1 EMAA_DEP2[2] ICNTL_MID_1V.NEMAA_DEP1[2] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I73_0.I2.MXNA1 ICNTL_MID_1V.NEMAWA_DEP1[0] EMAWA[0] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I73_0.I2.MXPA1 ICNTL_MID_1V.NEMAWA_DEP1[0] EMAWA[0] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I73_1.I2.MXNA1 ICNTL_MID_1V.NEMAWA_DEP1[1] EMAWA[1] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I73_1.I2.MXPA1 ICNTL_MID_1V.NEMAWA_DEP1[1] EMAWA[1] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I73_2.I2.MXNA1 ICNTL_MID_1V.NEMAA_DEP1[0] EMAA[0] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I73_2.I2.MXPA1 ICNTL_MID_1V.NEMAA_DEP1[0] EMAA[0] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I73_3.I2.MXNA1 ICNTL_MID_1V.NEMAA_DEP1[1] EMAA[1] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I73_3.I2.MXPA1 ICNTL_MID_1V.NEMAA_DEP1[1] EMAA[1] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I73_4.I2.MXNA1 ICNTL_MID_1V.NEMAA_DEP1[2] EMAA[2] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I73_4.I2.MXPA1 ICNTL_MID_1V.NEMAA_DEP1[2] EMAA[2] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I94.I94.MXN0 ZERO_C ICNTL_MID_1V.I94.I94.NODEB VSSE VPW
+  N11LL_CKT W=0.51U L=0.04U
X_MIcntl_mid_1v.I94.I94.MXN1 ICNTL_MID_1V.I94.I94.NODEA
+  ICNTL_MID_1V.I94.I94.NODEA VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.I94.I94.MXN2 ICNTL_MID_1V.I94.I94.NODEA
+  ICNTL_MID_1V.I94.I94.NODEB VSSE VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.I94.I94.MXP1 ICNTL_MID_1V.I94.I94.NODEB
+  ICNTL_MID_1V.I94.I94.NODEA VDDCE VNWC P11LL_CKT W=0.39U L=0.04U
X_MIcntl_mid_1v.I94.I94.MXP4 ONE_C ICNTL_MID_1V.I94.I94.NODEA VDDCE VNWC
+  P11LL_CKT W=1.03U L=0.04U
X_MIcntl_mid_1v.I98_0.I2.MXNA1 ICNTL_MID_1V.NEMAWB_DEP1[0] EMAWB[0] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I98_0.I2.MXPA1 ICNTL_MID_1V.NEMAWB_DEP1[0] EMAWB[0] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I98_1.I2.MXNA1 ICNTL_MID_1V.NEMAWB_DEP1[1] EMAWB[1] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I98_1.I2.MXPA1 ICNTL_MID_1V.NEMAWB_DEP1[1] EMAWB[1] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I98_2.I2.MXNA1 ICNTL_MID_1V.NEMAB_DEP1[0] EMAB[0] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I98_2.I2.MXPA1 ICNTL_MID_1V.NEMAB_DEP1[0] EMAB[0] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I98_3.I2.MXNA1 ICNTL_MID_1V.NEMAB_DEP1[1] EMAB[1] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I98_3.I2.MXPA1 ICNTL_MID_1V.NEMAB_DEP1[1] EMAB[1] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I98_4.I2.MXNA1 ICNTL_MID_1V.NEMAB_DEP1[2] EMAB[2] VSS VPW
+  N11LL_CKT W=0.97U L=0.04U
X_MIcntl_mid_1v.I98_4.I2.MXPA1 ICNTL_MID_1V.NEMAB_DEP1[2] EMAB[2] VDDPE VNWP
+  P11LL_CKT W=1.87U L=0.04U
X_MIcntl_mid_1v.I99_0.I2.MXNA1 EMAWB_DEP2[0] ICNTL_MID_1V.NEMAWB_DEP1[0] VSS
+  VPW N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I99_0.I2.MXPA1 EMAWB_DEP2[0] ICNTL_MID_1V.NEMAWB_DEP1[0] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I99_1.I2.MXNA1 EMAWB_DEP2[1] ICNTL_MID_1V.NEMAWB_DEP1[1] VSS
+  VPW N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I99_1.I2.MXPA1 EMAWB_DEP2[1] ICNTL_MID_1V.NEMAWB_DEP1[1] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I99_2.I2.MXNA1 EMAB_DEP2[0] ICNTL_MID_1V.NEMAB_DEP1[0] VSS VPW
+  N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I99_2.I2.MXPA1 EMAB_DEP2[0] ICNTL_MID_1V.NEMAB_DEP1[0] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I99_3.I2.MXNA1 EMAB_DEP2[1] ICNTL_MID_1V.NEMAB_DEP1[1] VSS VPW
+  N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I99_3.I2.MXPA1 EMAB_DEP2[1] ICNTL_MID_1V.NEMAB_DEP1[1] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.I99_4.I2.MXNA1 EMAB_DEP2[2] ICNTL_MID_1V.NEMAB_DEP1[2] VSS VPW
+  N11LL_CKT W=3.76U L=0.04U
X_MIcntl_mid_1v.I99_4.I2.MXPA1 EMAB_DEP2[2] ICNTL_MID_1V.NEMAB_DEP1[2] VDDPE
+  VNWP P11LL_CKT W=7.8U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I1.MXNA1 NWRB_MA ICNTL_MID_1V.ICOLL_COMP.MA
+  ICNTL_MID_1V.ICOLL_COMP.I1.N1 VPW N11LL_CKT W=1.92U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I1.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I1.N1
+  ICNTL_MID_1V.ICOLL_COMP.WRB VSS VPW N11LL_CKT W=1.92U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I1.MXPA1 NWRB_MA ICNTL_MID_1V.ICOLL_COMP.MA VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I1.MXPA2 NWRB_MA ICNTL_MID_1V.ICOLL_COMP.WRB VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I232.MXNA1 ICNTL_MID_1V.ICOLL_COMP.GWEA NGWE_A VSS
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I232.MXPA1 ICNTL_MID_1V.ICOLL_COMP.GWEA NGWE_A
+  VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I233.MXNA1 ICNTL_MID_1V.ICOLL_COMP.GWEB NGWE_B VSS
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I233.MXPA1 ICNTL_MID_1V.ICOLL_COMP.GWEB NGWE_B
+  VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I234.MXNA1 ICNTL_MID_1V.ICOLL_COMP.WRA
+  ICNTL_MID_1V.ICOLL_COMP.WRA_N VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I234.MXPA1 ICNTL_MID_1V.ICOLL_COMP.WRA
+  ICNTL_MID_1V.ICOLL_COMP.WRA_N VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I236.MXNA1 ICNTL_MID_1V.ICOLL_COMP.WRB
+  ICNTL_MID_1V.ICOLL_COMP.WRB_N VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I236.MXPA1 ICNTL_MID_1V.ICOLL_COMP.WRB
+  ICNTL_MID_1V.ICOLL_COMP.WRB_N VDDPE VNWP P11LL_CKT W=1.14U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I241_0.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[0] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I241_0.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[0] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH0[0]
+  ICNTL_MID_1V.ICOLL_COMP.I241_0.AN ICNTL_MID_1V.ICOLL_COMP.I241_0.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH0[0]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[0] ICNTL_MID_1V.ICOLL_COMP.I241_0.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH0[0]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[0] ICNTL_MID_1V.ICOLL_COMP.I241_0.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH0[0]
+  ICNTL_MID_1V.ICOLL_COMP.I241_0.AN ICNTL_MID_1V.ICOLL_COMP.I241_0.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I241_0.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[0] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I241_0.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[0] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I31.MXNA1
+  ICNTL_MID_1V.ICOLL_COMP.I241_0.BBUF ICNTL_MID_1V.ICOLL_COMP.I241_0.BN VSS
+  VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_0.I31.MXPA1
+  ICNTL_MID_1V.ICOLL_COMP.I241_0.BBUF ICNTL_MID_1V.ICOLL_COMP.I241_0.BN VDDPE
+  VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I241_1.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[1] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I241_1.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[1] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH0[1]
+  ICNTL_MID_1V.ICOLL_COMP.I241_1.AN ICNTL_MID_1V.ICOLL_COMP.I241_1.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH0[1]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[1] ICNTL_MID_1V.ICOLL_COMP.I241_1.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH0[1]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[1] ICNTL_MID_1V.ICOLL_COMP.I241_1.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH0[1]
+  ICNTL_MID_1V.ICOLL_COMP.I241_1.AN ICNTL_MID_1V.ICOLL_COMP.I241_1.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I241_1.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[1] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I241_1.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[1] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I31.MXNA1
+  ICNTL_MID_1V.ICOLL_COMP.I241_1.BBUF ICNTL_MID_1V.ICOLL_COMP.I241_1.BN VSS
+  VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_1.I31.MXPA1
+  ICNTL_MID_1V.ICOLL_COMP.I241_1.BBUF ICNTL_MID_1V.ICOLL_COMP.I241_1.BN VDDPE
+  VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I241_2.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[2] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I241_2.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[2] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH0[2]
+  ICNTL_MID_1V.ICOLL_COMP.I241_2.AN ICNTL_MID_1V.ICOLL_COMP.I241_2.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH0[2]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[2] ICNTL_MID_1V.ICOLL_COMP.I241_2.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH0[2]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[2] ICNTL_MID_1V.ICOLL_COMP.I241_2.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH0[2]
+  ICNTL_MID_1V.ICOLL_COMP.I241_2.AN ICNTL_MID_1V.ICOLL_COMP.I241_2.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I241_2.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[2] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I241_2.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[2] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I31.MXNA1
+  ICNTL_MID_1V.ICOLL_COMP.I241_2.BBUF ICNTL_MID_1V.ICOLL_COMP.I241_2.BN VSS
+  VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I241_2.I31.MXPA1
+  ICNTL_MID_1V.ICOLL_COMP.I241_2.BBUF ICNTL_MID_1V.ICOLL_COMP.I241_2.BN VDDPE
+  VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I242.MXNA1 ICNTL_MID_1V.ICOLL_COMP.M0_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH0[2] ICNTL_MID_1V.ICOLL_COMP.I242.N2 VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I242.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I242.N2
+  ICNTL_MID_1V.ICOLL_COMP.MATCH0[1] ICNTL_MID_1V.ICOLL_COMP.I242.N1 VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I242.MXNA3 ICNTL_MID_1V.ICOLL_COMP.I242.N1
+  ICNTL_MID_1V.ICOLL_COMP.MATCH0[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I242.MXPA1 ICNTL_MID_1V.ICOLL_COMP.M0_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH0[2] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I242.MXPA2 ICNTL_MID_1V.ICOLL_COMP.M0_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH0[1] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I242.MXPA3 ICNTL_MID_1V.ICOLL_COMP.M0_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH0[0] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I248.MXNA1 ICNTL_MID_1V.ICOLL_COMP.WRA_N
+  ICNTL_MID_1V.ICOLL_COMP.GWEA ICNTL_MID_1V.ICOLL_COMP.I248.N1 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I248.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I248.N1 COLLDISN
+  VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I248.MXPA1 ICNTL_MID_1V.ICOLL_COMP.WRA_N
+  ICNTL_MID_1V.ICOLL_COMP.GWEA VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I248.MXPA2 ICNTL_MID_1V.ICOLL_COMP.WRA_N COLLDISN
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_0.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[3] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_0.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[3] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH1[0]
+  ICNTL_MID_1V.ICOLL_COMP.I27_0.AN ICNTL_MID_1V.ICOLL_COMP.I27_0.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH1[0]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[3] ICNTL_MID_1V.ICOLL_COMP.I27_0.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH1[0]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[3] ICNTL_MID_1V.ICOLL_COMP.I27_0.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH1[0]
+  ICNTL_MID_1V.ICOLL_COMP.I27_0.AN ICNTL_MID_1V.ICOLL_COMP.I27_0.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_0.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[3] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_0.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[3] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I31.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_0.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I27_0.BN VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_0.I31.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_0.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I27_0.BN VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_1.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[4] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_1.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[4] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH1[1]
+  ICNTL_MID_1V.ICOLL_COMP.I27_1.AN ICNTL_MID_1V.ICOLL_COMP.I27_1.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH1[1]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[4] ICNTL_MID_1V.ICOLL_COMP.I27_1.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH1[1]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[4] ICNTL_MID_1V.ICOLL_COMP.I27_1.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH1[1]
+  ICNTL_MID_1V.ICOLL_COMP.I27_1.AN ICNTL_MID_1V.ICOLL_COMP.I27_1.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_1.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[4] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_1.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[4] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I31.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_1.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I27_1.BN VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_1.I31.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_1.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I27_1.BN VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_2.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[5] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_2.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[5] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH1[2]
+  ICNTL_MID_1V.ICOLL_COMP.I27_2.AN ICNTL_MID_1V.ICOLL_COMP.I27_2.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH1[2]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[5] ICNTL_MID_1V.ICOLL_COMP.I27_2.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH1[2]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[5] ICNTL_MID_1V.ICOLL_COMP.I27_2.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH1[2]
+  ICNTL_MID_1V.ICOLL_COMP.I27_2.AN ICNTL_MID_1V.ICOLL_COMP.I27_2.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_2.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[5] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_2.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[5] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I31.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I27_2.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I27_2.BN VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I27_2.I31.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I27_2.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I27_2.BN VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I28.MXNA1 ICNTL_MID_1V.ICOLL_COMP.MA_N
+  ICNTL_MID_1V.ICOLL_COMP.M0 ICNTL_MID_1V.ICOLL_COMP.I28.N2 VPW N11LL_CKT
+  W=0.595U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I28.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I28.N2
+  ICNTL_MID_1V.ICOLL_COMP.M1 ICNTL_MID_1V.ICOLL_COMP.I28.N1 VPW N11LL_CKT
+  W=0.595U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I28.MXNA3 ICNTL_MID_1V.ICOLL_COMP.I28.N1
+  ICNTL_MID_1V.ICOLL_COMP.M2 VSS VPW N11LL_CKT W=0.595U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I28.MXPA1 ICNTL_MID_1V.ICOLL_COMP.MA_N
+  ICNTL_MID_1V.ICOLL_COMP.M0 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I28.MXPA2 ICNTL_MID_1V.ICOLL_COMP.MA_N
+  ICNTL_MID_1V.ICOLL_COMP.M1 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I28.MXPA3 ICNTL_MID_1V.ICOLL_COMP.MA_N
+  ICNTL_MID_1V.ICOLL_COMP.M2 VDDPE VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I30_0.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[6] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I30_0.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[6] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH2[0]
+  ICNTL_MID_1V.ICOLL_COMP.I30_0.AN ICNTL_MID_1V.ICOLL_COMP.I30_0.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH2[0]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[6] ICNTL_MID_1V.ICOLL_COMP.I30_0.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH2[0]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[6] ICNTL_MID_1V.ICOLL_COMP.I30_0.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH2[0]
+  ICNTL_MID_1V.ICOLL_COMP.I30_0.AN ICNTL_MID_1V.ICOLL_COMP.I30_0.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I30_0.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[6] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I30_0.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[6] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I31.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I30_0.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I30_0.BN VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_0.I31.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I30_0.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I30_0.BN VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I23.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I30_1.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[7] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I23.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I30_1.AN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[7] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I26.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH2[1]
+  ICNTL_MID_1V.ICOLL_COMP.I30_1.AN ICNTL_MID_1V.ICOLL_COMP.I30_1.BN VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I26.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH2[1]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[7] ICNTL_MID_1V.ICOLL_COMP.I30_1.BN VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I27.MXNOE ICNTL_MID_1V.ICOLL_COMP.MATCH2[1]
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_A[7] ICNTL_MID_1V.ICOLL_COMP.I30_1.BBUF VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I27.MXPOEN ICNTL_MID_1V.ICOLL_COMP.MATCH2[1]
+  ICNTL_MID_1V.ICOLL_COMP.I30_1.AN ICNTL_MID_1V.ICOLL_COMP.I30_1.BBUF VNWP
+  P11LL_CKT W=0.995U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I30.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I30_1.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[7] VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I30.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I30_1.BN
+  ICNTL_MID_1V.ICOLL_COMP.NADDR_B[7] VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I31.MXNA1 ICNTL_MID_1V.ICOLL_COMP.I30_1.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I30_1.BN VSS VPW N11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I30_1.I31.MXPA1 ICNTL_MID_1V.ICOLL_COMP.I30_1.BBUF
+  ICNTL_MID_1V.ICOLL_COMP.I30_1.BN VDDPE VNWP P11LL_CKT W=1.195U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I4.MXNA1 NWRA_MA ICNTL_MID_1V.ICOLL_COMP.MA
+  ICNTL_MID_1V.ICOLL_COMP.I4.N1 VPW N11LL_CKT W=1.92U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I4.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I4.N1
+  ICNTL_MID_1V.ICOLL_COMP.WRA VSS VPW N11LL_CKT W=1.92U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I4.MXPA1 NWRA_MA ICNTL_MID_1V.ICOLL_COMP.MA VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I4.MXPA2 NWRA_MA ICNTL_MID_1V.ICOLL_COMP.WRA VDDPE
+  VNWP P11LL_CKT W=2U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I6.MXNA1 ICNTL_MID_1V.ICOLL_COMP.M2_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH2[1] ICNTL_MID_1V.ICOLL_COMP.I6.N1 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I6.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I6.N1
+  ICNTL_MID_1V.ICOLL_COMP.MATCH2[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I6.MXPA1 ICNTL_MID_1V.ICOLL_COMP.M2_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH2[1] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I6.MXPA2 ICNTL_MID_1V.ICOLL_COMP.M2_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH2[0] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I7.MXNA1 ICNTL_MID_1V.ICOLL_COMP.M1_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH1[2] ICNTL_MID_1V.ICOLL_COMP.I7.N2 VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I7.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I7.N2
+  ICNTL_MID_1V.ICOLL_COMP.MATCH1[1] ICNTL_MID_1V.ICOLL_COMP.I7.N1 VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I7.MXNA3 ICNTL_MID_1V.ICOLL_COMP.I7.N1
+  ICNTL_MID_1V.ICOLL_COMP.MATCH1[0] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I7.MXPA1 ICNTL_MID_1V.ICOLL_COMP.M1_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH1[2] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I7.MXPA2 ICNTL_MID_1V.ICOLL_COMP.M1_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH1[1] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I7.MXPA3 ICNTL_MID_1V.ICOLL_COMP.M1_N
+  ICNTL_MID_1V.ICOLL_COMP.MATCH1[0] VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_0.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[0]
+  RADDR_A[0] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_0.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[0]
+  RADDR_A[0] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_1.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[1]
+  RADDR_A[1] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_1.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[1]
+  RADDR_A[1] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_2.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[2]
+  RADDR_A[2] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_2.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[2]
+  RADDR_A[2] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_3.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[3]
+  RADDR_A[3] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_3.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[3]
+  RADDR_A[3] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_4.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[4]
+  RADDR_A[4] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_4.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[4]
+  RADDR_A[4] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_5.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[5]
+  RADDR_A[5] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_5.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[5]
+  RADDR_A[5] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_6.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[6]
+  RADDR_A[6] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_6.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[6]
+  RADDR_A[6] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_7.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[7]
+  RADDR_A[7] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I78_7.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_A[7]
+  RADDR_A[7] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_0.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[0]
+  RADDR_B[0] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_0.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[0]
+  RADDR_B[0] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_1.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[1]
+  RADDR_B[1] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_1.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[1]
+  RADDR_B[1] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_2.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[2]
+  RADDR_B[2] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_2.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[2]
+  RADDR_B[2] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_3.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[3]
+  RADDR_B[3] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_3.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[3]
+  RADDR_B[3] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_4.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[4]
+  RADDR_B[4] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_4.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[4]
+  RADDR_B[4] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_5.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[5]
+  RADDR_B[5] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_5.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[5]
+  RADDR_B[5] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_6.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[6]
+  RADDR_B[6] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_6.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[6]
+  RADDR_B[6] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_7.MXNA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[7]
+  RADDR_B[7] VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I79_7.MXPA1 ICNTL_MID_1V.ICOLL_COMP.NADDR_B[7]
+  RADDR_B[7] VDDPE VNWP P11LL_CKT W=0.445U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I8.MXNA1 ICNTL_MID_1V.ICOLL_COMP.WRB_N
+  ICNTL_MID_1V.ICOLL_COMP.GWEB ICNTL_MID_1V.ICOLL_COMP.I8.N1 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I8.MXNA2 ICNTL_MID_1V.ICOLL_COMP.I8.N1 COLLDISN VSS
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I8.MXPA1 ICNTL_MID_1V.ICOLL_COMP.WRB_N
+  ICNTL_MID_1V.ICOLL_COMP.GWEB VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I8.MXPA2 ICNTL_MID_1V.ICOLL_COMP.WRB_N COLLDISN
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I83.MXNA1 ICNTL_MID_1V.ICOLL_COMP.MA
+  ICNTL_MID_1V.ICOLL_COMP.MA_N VSS VPW N11LL_CKT W=0.71U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I83.MXPA1 ICNTL_MID_1V.ICOLL_COMP.MA
+  ICNTL_MID_1V.ICOLL_COMP.MA_N VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I84.MXNA1 ICNTL_MID_1V.ICOLL_COMP.M0
+  ICNTL_MID_1V.ICOLL_COMP.M0_N VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I84.MXPA1 ICNTL_MID_1V.ICOLL_COMP.M0
+  ICNTL_MID_1V.ICOLL_COMP.M0_N VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I85.MXNA1 ICNTL_MID_1V.ICOLL_COMP.M1
+  ICNTL_MID_1V.ICOLL_COMP.M1_N VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I85.MXPA1 ICNTL_MID_1V.ICOLL_COMP.M1
+  ICNTL_MID_1V.ICOLL_COMP.M1_N VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I86.MXNA1 ICNTL_MID_1V.ICOLL_COMP.M2
+  ICNTL_MID_1V.ICOLL_COMP.M2_N VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Icoll_comp.I86.MXPA1 ICNTL_MID_1V.ICOLL_COMP.M2
+  ICNTL_MID_1V.ICOLL_COMP.M2_N VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.I30.MXNA1 ICNTL_MID_1V.IHDR_CTL_0.HDR_WL
+  ICNTL_MID_1V.IHDR_CTL_0.NET15 VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.I30.MXPA1 ICNTL_MID_1V.IHDR_CTL_0.HDR_WL
+  ICNTL_MID_1V.IHDR_CTL_0.NET15 VDDCE VNWC P11LL_CKT W=2.19U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.I63.MXNA1 NHDR_WL_B ICNTL_MID_1V.IHDR_CTL_0.HDR_WL
+  VSSE VPW N11LL_CKT W=5.67U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.I63.MXPA1 NHDR_WL_B ICNTL_MID_1V.IHDR_CTL_0.HDR_WL
+  VDDCE VNWC P11LL_CKT W=8.37U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.MXN0 ICNTL_MID_1V.IHDR_CTL_0.NET019 NRET_B VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.MXN1 ICNTL_MID_1V.IHDR_CTL_0.NET15
+  ICNTL_MID_1V.CE_B ICNTL_MID_1V.IHDR_CTL_0.NET019 VPW N11LL_CKT W=0.57U
+  L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.MXP3 ICNTL_MID_1V.IHDR_CTL_0.NET15
+  ICNTL_MID_1V.CE_B VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_0.MXP4 ICNTL_MID_1V.IHDR_CTL_0.NET15 NRET_B VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.I30.MXNA1 ICNTL_MID_1V.IHDR_CTL_1.HDR_WL
+  ICNTL_MID_1V.IHDR_CTL_1.NET15 VSSE VPW N11LL_CKT W=1.13U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.I30.MXPA1 ICNTL_MID_1V.IHDR_CTL_1.HDR_WL
+  ICNTL_MID_1V.IHDR_CTL_1.NET15 VDDCE VNWC P11LL_CKT W=2.19U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.I63.MXNA1 NHDR_WL_A ICNTL_MID_1V.IHDR_CTL_1.HDR_WL
+  VSSE VPW N11LL_CKT W=5.67U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.I63.MXPA1 NHDR_WL_A ICNTL_MID_1V.IHDR_CTL_1.HDR_WL
+  VDDCE VNWC P11LL_CKT W=8.37U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.MXN0 ICNTL_MID_1V.IHDR_CTL_1.NET019 NRET_A VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.MXN1 ICNTL_MID_1V.IHDR_CTL_1.NET15
+  ICNTL_MID_1V.CE_A ICNTL_MID_1V.IHDR_CTL_1.NET019 VPW N11LL_CKT W=0.57U
+  L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.MXP3 ICNTL_MID_1V.IHDR_CTL_1.NET15
+  ICNTL_MID_1V.CE_A VDDCE VNWC P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Ihdr_ctl_1.MXP4 ICNTL_MID_1V.IHDR_CTL_1.NET15 NRET_A VDDCE
+  VNWC P11LL_CKT W=0.285U L=0.04U
X_MIcntl_mid_1v.Ilogicgen.Ilogicgen.MXN0 ICNTL_MID_1V.ZERO
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEB VSS VPW N11LL_CKT W=0.51U L=0.04U
X_MIcntl_mid_1v.Ilogicgen.Ilogicgen.MXN1
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEA
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEA VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Ilogicgen.Ilogicgen.MXN2
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEA
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEB VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Ilogicgen.Ilogicgen.MXP1
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEB
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=0.39U L=0.04U
X_MIcntl_mid_1v.Ilogicgen.Ilogicgen.MXP4 ICNTL_MID_1V.ONE
+  ICNTL_MID_1V.ILOGICGEN.ILOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=1.04U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I24.MXNA1 RET1N_BUF ICNTL_MID_1V.IPG_CTL.NET34 VSSE
+  VPW N11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I24.MXPA1 RET1N_BUF ICNTL_MID_1V.IPG_CTL.NET34 VDDCE
+  VNWC P11LL_CKT W=0.595U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I27.MXNA1 ICNTL_MID_1V.IPG_CTL.RETB NIRET VSSE VPW
+  N11LL_CKT W=0.4U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I27.MXPA1 ICNTL_MID_1V.IPG_CTL.RETB NIRET VDDCE VNWC
+  P11LL_CKT W=0.795U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I34.MXNA1 ICNTL_MID_1V.IPG_CTL.RETA NIRET VSSE VPW
+  N11LL_CKT W=0.695U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I34.MXPA1 ICNTL_MID_1V.IPG_CTL.RETA NIRET VDDCE VNWC
+  P11LL_CKT W=1.39U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I37.MXNA1 ICNTL_MID_1V.IPG_CTL.NET34 RET1N
+  ICNTL_MID_1V.IPG_CTL.I37.N1 VPW N11LL_CKT W=0.2U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I37.MXNA2 ICNTL_MID_1V.IPG_CTL.I37.N1 LOG1 VSSE VPW
+  N11LL_CKT W=0.2U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I37.MXPA1 ICNTL_MID_1V.IPG_CTL.NET34 RET1N VDDCE VNWC
+  P11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I37.MXPA2 ICNTL_MID_1V.IPG_CTL.NET34 LOG1 VDDCE VNWC
+  P11LL_CKT W=0.3U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I39.MXNA1 NRET_A ICNTL_MID_1V.IPG_CTL.RETA VSSE VPW
+  N11LL_CKT W=1.995U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I39.MXPA1 NRET_A ICNTL_MID_1V.IPG_CTL.RETA VDDCE VNWC
+  P11LL_CKT W=3.855U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I40.MXNA1 NRET_B ICNTL_MID_1V.IPG_CTL.RETB VSSE VPW
+  N11LL_CKT W=1.92U L=0.04U
X_MIcntl_mid_1v.Ipg_ctl.I40.MXPA1 NRET_B ICNTL_MID_1V.IPG_CTL.RETB VDDCE VNWC
+  P11LL_CKT W=3.855U L=0.04U
X_MIcntl_mid_1v.Irdta.I49.MXNA1 ICNTL_MID_1V.IRDTA.NCLK ICNTL_MID_1V.CLK_CTL_A
+  VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIcntl_mid_1v.Irdta.I49.MXPA1 ICNTL_MID_1V.IRDTA.NCLK ICNTL_MID_1V.CLK_CTL_A
+  VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIcntl_mid_1v.Irdta.I7.MXNA1 NRDTA ICNTL_MID_1V.IRDTA.NA_LAT VSS VPW
+  N11LL_CKT W=2.26U L=0.04U
X_MIcntl_mid_1v.Irdta.I7.MXPA1 NRDTA ICNTL_MID_1V.IRDTA.NA_LAT VDDPE VNWP
+  P11LL_CKT W=4.38U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I47.MXNA1 ICNTL_MID_1V.IRDTA.ILAT.ND RDTA VSS VPW
+  N11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I47.MXPA1 ICNTL_MID_1V.IRDTA.ILAT.ND RDTA VDDPE
+  VNWP P11LL_CKT W=0.825U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I48.MXNOE ICNTL_MID_1V.IRDTA.NQ_INT
+  ICNTL_MID_1V.IRDTA.NCLK ICNTL_MID_1V.IRDTA.ILAT.ND VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I48.MXPOEN ICNTL_MID_1V.IRDTA.NQ_INT
+  ICNTL_MID_1V.CLK_CTL_A ICNTL_MID_1V.IRDTA.ILAT.ND VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I50.MXNA1 ICNTL_MID_1V.IRDTA.NA_LAT
+  ICNTL_MID_1V.IRDTA.NQ_INT VSS VPW N11LL_CKT W=0.72U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I50.MXPA1 ICNTL_MID_1V.IRDTA.NA_LAT
+  ICNTL_MID_1V.IRDTA.NQ_INT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I55.MXNA1 ICNTL_MID_1V.IRDTA.ILAT.I55.N1
+  ICNTL_MID_1V.IRDTA.NA_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I55.MXNOE ICNTL_MID_1V.IRDTA.NQ_INT
+  ICNTL_MID_1V.CLK_CTL_A ICNTL_MID_1V.IRDTA.ILAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I55.MXPA1 ICNTL_MID_1V.IRDTA.ILAT.I55.P1
+  ICNTL_MID_1V.IRDTA.NA_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIcntl_mid_1v.Irdta.Ilat.I55.MXPOEN ICNTL_MID_1V.IRDTA.NQ_INT
+  ICNTL_MID_1V.IRDTA.NCLK ICNTL_MID_1V.IRDTA.ILAT.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_MIcntl_mid_1v.Irdtb.I49.MXNA1 ICNTL_MID_1V.IRDTB.NCLK ICNTL_MID_1V.CLK_CTL_B
+  VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIcntl_mid_1v.Irdtb.I49.MXPA1 ICNTL_MID_1V.IRDTB.NCLK ICNTL_MID_1V.CLK_CTL_B
+  VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIcntl_mid_1v.Irdtb.I7.MXNA1 NRDTB ICNTL_MID_1V.IRDTB.NA_LAT VSS VPW
+  N11LL_CKT W=2.26U L=0.04U
X_MIcntl_mid_1v.Irdtb.I7.MXPA1 NRDTB ICNTL_MID_1V.IRDTB.NA_LAT VDDPE VNWP
+  P11LL_CKT W=4.38U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I47.MXNA1 ICNTL_MID_1V.IRDTB.ILAT.ND RDTB VSS VPW
+  N11LL_CKT W=0.57U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I47.MXPA1 ICNTL_MID_1V.IRDTB.ILAT.ND RDTB VDDPE
+  VNWP P11LL_CKT W=0.825U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I48.MXNOE ICNTL_MID_1V.IRDTB.NQ_INT
+  ICNTL_MID_1V.IRDTB.NCLK ICNTL_MID_1V.IRDTB.ILAT.ND VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I48.MXPOEN ICNTL_MID_1V.IRDTB.NQ_INT
+  ICNTL_MID_1V.CLK_CTL_B ICNTL_MID_1V.IRDTB.ILAT.ND VNWP P11LL_CKT W=0.71U
+  L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I50.MXNA1 ICNTL_MID_1V.IRDTB.NA_LAT
+  ICNTL_MID_1V.IRDTB.NQ_INT VSS VPW N11LL_CKT W=0.72U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I50.MXPA1 ICNTL_MID_1V.IRDTB.NA_LAT
+  ICNTL_MID_1V.IRDTB.NQ_INT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I55.MXNA1 ICNTL_MID_1V.IRDTB.ILAT.I55.N1
+  ICNTL_MID_1V.IRDTB.NA_LAT VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I55.MXNOE ICNTL_MID_1V.IRDTB.NQ_INT
+  ICNTL_MID_1V.CLK_CTL_B ICNTL_MID_1V.IRDTB.ILAT.I55.N1 VPW N11LL_CKT W=0.15U
+  L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I55.MXPA1 ICNTL_MID_1V.IRDTB.ILAT.I55.P1
+  ICNTL_MID_1V.IRDTB.NA_LAT VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIcntl_mid_1v.Irdtb.Ilat.I55.MXPOEN ICNTL_MID_1V.IRDTB.NQ_INT
+  ICNTL_MID_1V.IRDTB.NCLK ICNTL_MID_1V.IRDTB.ILAT.I55.P1 VNWP P11LL_CKT
+  W=0.15U L=0.04U
X_MIcntl_mid_1v.Iret_inv_0.I2.MXNA1 NRET_ACT_FT2_A ICNTL_MID_1V.BRET_ACT_FT2_A
+  VSSE VPW N11LL_CKT W=1.98U L=0.04U
X_MIcntl_mid_1v.Iret_inv_0.I2.MXPA1 NRET_ACT_FT2_A ICNTL_MID_1V.BRET_ACT_FT2_A
+  VDDCE VNWC P11LL_CKT W=3.9U L=0.04U
X_MIcntl_mid_1v.Iret_inv_1.I2.MXNA1 NRET_ACT_FT1_A ICNTL_MID_1V.BRET_ACT_FT1_A
+  VSSE VPW N11LL_CKT W=1.98U L=0.04U
X_MIcntl_mid_1v.Iret_inv_1.I2.MXPA1 NRET_ACT_FT1_A ICNTL_MID_1V.BRET_ACT_FT1_A
+  VDDCE VNWC P11LL_CKT W=3.9U L=0.04U
X_MIcntl_mid_1v.Iretinv_0.I2.MXNA1 RET_B NRET_B VSSE VPW N11LL_CKT W=6.72U
+  L=0.04U
X_MIcntl_mid_1v.Iretinv_0.I2.MXPA1 RET_B NRET_B VDDCE VNWC P11LL_CKT W=13.48U
+  L=0.04U
X_MIcntl_mid_1v.Iretinv_1.I2.MXNA1 RET_A NRET_A VSSE VPW N11LL_CKT W=6.72U
+  L=0.04U
X_MIcntl_mid_1v.Iretinv_1.I2.MXPA1 RET_A NRET_A VDDCE VNWC P11LL_CKT W=13.48U
+  L=0.04U
X_MIcntl_mid_1v.MXN0 LOG0 ICNTL_MID_1V.ONE VSS VPW N11LL_CKT W=5.94U L=0.04U
X_MIcntl_mid_1v.MXP0 LOG1 ICNTL_MID_1V.ZERO VDDPE VNWP P11LL_CKT W=1.92U
+  L=0.04U
X_MIpdec1.I16_0.MXNA1 IPDEC1.ADDR[0] NRADDR_A[0] VSS VPW N11LL_CKT W=0.96U
+  L=0.04U
X_MIpdec1.I16_0.MXPA1 IPDEC1.ADDR[0] NRADDR_A[0] VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIpdec1.I16_1.MXNA1 IPDEC1.ADDR[1] NRADDR_A[1] VSS VPW N11LL_CKT W=0.96U
+  L=0.04U
X_MIpdec1.I16_1.MXPA1 IPDEC1.ADDR[1] NRADDR_A[1] VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIpdec1.I16_2.MXNA1 IPDEC1.ADDR[2] NRADDR_A[2] VSS VPW N11LL_CKT W=0.96U
+  L=0.04U
X_MIpdec1.I16_2.MXPA1 IPDEC1.ADDR[2] NRADDR_A[2] VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIpdec1.Iand_0.I17.MXNA1 IPDEC1.IAND_0.DEC IPDEC1.IAND_0.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_0.I17.MXPA1 IPDEC1.IAND_0.DEC IPDEC1.IAND_0.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_0.I19.MXNA1 NXPDEC1_A[0] IPDEC1.IAND_0.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_0.I19.MXPA1 NXPDEC1_A[0] IPDEC1.IAND_0.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_0.I9.MXNA1 IPDEC1.IAND_0.DEC_N NRADDR_A[2] IPDEC1.IAND_0.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_0.I9.MXNA2 IPDEC1.IAND_0.I9.N2 NRADDR_A[1] IPDEC1.IAND_0.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_0.I9.MXNA3 IPDEC1.IAND_0.I9.N1 NRADDR_A[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_0.I9.MXPA1 IPDEC1.IAND_0.DEC_N NRADDR_A[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_0.I9.MXPA2 IPDEC1.IAND_0.DEC_N NRADDR_A[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_0.I9.MXPA3 IPDEC1.IAND_0.DEC_N NRADDR_A[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_1.I17.MXNA1 IPDEC1.IAND_1.DEC IPDEC1.IAND_1.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_1.I17.MXPA1 IPDEC1.IAND_1.DEC IPDEC1.IAND_1.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_1.I19.MXNA1 NXPDEC1_A[1] IPDEC1.IAND_1.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_1.I19.MXPA1 NXPDEC1_A[1] IPDEC1.IAND_1.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_1.I9.MXNA1 IPDEC1.IAND_1.DEC_N NRADDR_A[2] IPDEC1.IAND_1.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_1.I9.MXNA2 IPDEC1.IAND_1.I9.N2 NRADDR_A[1] IPDEC1.IAND_1.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_1.I9.MXNA3 IPDEC1.IAND_1.I9.N1 IPDEC1.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_1.I9.MXPA1 IPDEC1.IAND_1.DEC_N NRADDR_A[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_1.I9.MXPA2 IPDEC1.IAND_1.DEC_N NRADDR_A[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_1.I9.MXPA3 IPDEC1.IAND_1.DEC_N IPDEC1.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_2.I17.MXNA1 IPDEC1.IAND_2.DEC IPDEC1.IAND_2.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_2.I17.MXPA1 IPDEC1.IAND_2.DEC IPDEC1.IAND_2.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_2.I19.MXNA1 NXPDEC1_A[2] IPDEC1.IAND_2.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_2.I19.MXPA1 NXPDEC1_A[2] IPDEC1.IAND_2.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_2.I9.MXNA1 IPDEC1.IAND_2.DEC_N NRADDR_A[2] IPDEC1.IAND_2.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_2.I9.MXNA2 IPDEC1.IAND_2.I9.N2 IPDEC1.ADDR[1]
+  IPDEC1.IAND_2.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_2.I9.MXNA3 IPDEC1.IAND_2.I9.N1 NRADDR_A[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_2.I9.MXPA1 IPDEC1.IAND_2.DEC_N NRADDR_A[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_2.I9.MXPA2 IPDEC1.IAND_2.DEC_N IPDEC1.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_2.I9.MXPA3 IPDEC1.IAND_2.DEC_N NRADDR_A[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_3.I17.MXNA1 IPDEC1.IAND_3.DEC IPDEC1.IAND_3.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_3.I17.MXPA1 IPDEC1.IAND_3.DEC IPDEC1.IAND_3.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_3.I19.MXNA1 NXPDEC1_A[3] IPDEC1.IAND_3.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_3.I19.MXPA1 NXPDEC1_A[3] IPDEC1.IAND_3.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_3.I9.MXNA1 IPDEC1.IAND_3.DEC_N NRADDR_A[2] IPDEC1.IAND_3.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_3.I9.MXNA2 IPDEC1.IAND_3.I9.N2 IPDEC1.ADDR[1]
+  IPDEC1.IAND_3.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_3.I9.MXNA3 IPDEC1.IAND_3.I9.N1 IPDEC1.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_3.I9.MXPA1 IPDEC1.IAND_3.DEC_N NRADDR_A[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_3.I9.MXPA2 IPDEC1.IAND_3.DEC_N IPDEC1.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_3.I9.MXPA3 IPDEC1.IAND_3.DEC_N IPDEC1.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_4.I17.MXNA1 IPDEC1.IAND_4.DEC IPDEC1.IAND_4.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_4.I17.MXPA1 IPDEC1.IAND_4.DEC IPDEC1.IAND_4.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_4.I19.MXNA1 NXPDEC1_A[4] IPDEC1.IAND_4.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_4.I19.MXPA1 NXPDEC1_A[4] IPDEC1.IAND_4.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_4.I9.MXNA1 IPDEC1.IAND_4.DEC_N IPDEC1.ADDR[2]
+  IPDEC1.IAND_4.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_4.I9.MXNA2 IPDEC1.IAND_4.I9.N2 NRADDR_A[1] IPDEC1.IAND_4.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_4.I9.MXNA3 IPDEC1.IAND_4.I9.N1 NRADDR_A[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_4.I9.MXPA1 IPDEC1.IAND_4.DEC_N IPDEC1.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_4.I9.MXPA2 IPDEC1.IAND_4.DEC_N NRADDR_A[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_4.I9.MXPA3 IPDEC1.IAND_4.DEC_N NRADDR_A[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_5.I17.MXNA1 IPDEC1.IAND_5.DEC IPDEC1.IAND_5.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_5.I17.MXPA1 IPDEC1.IAND_5.DEC IPDEC1.IAND_5.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_5.I19.MXNA1 NXPDEC1_A[5] IPDEC1.IAND_5.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_5.I19.MXPA1 NXPDEC1_A[5] IPDEC1.IAND_5.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_5.I9.MXNA1 IPDEC1.IAND_5.DEC_N IPDEC1.ADDR[2]
+  IPDEC1.IAND_5.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_5.I9.MXNA2 IPDEC1.IAND_5.I9.N2 NRADDR_A[1] IPDEC1.IAND_5.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_5.I9.MXNA3 IPDEC1.IAND_5.I9.N1 IPDEC1.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_5.I9.MXPA1 IPDEC1.IAND_5.DEC_N IPDEC1.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_5.I9.MXPA2 IPDEC1.IAND_5.DEC_N NRADDR_A[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_5.I9.MXPA3 IPDEC1.IAND_5.DEC_N IPDEC1.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_6.I17.MXNA1 IPDEC1.IAND_6.DEC IPDEC1.IAND_6.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_6.I17.MXPA1 IPDEC1.IAND_6.DEC IPDEC1.IAND_6.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_6.I19.MXNA1 NXPDEC1_A[6] IPDEC1.IAND_6.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_6.I19.MXPA1 NXPDEC1_A[6] IPDEC1.IAND_6.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_6.I9.MXNA1 IPDEC1.IAND_6.DEC_N IPDEC1.ADDR[2]
+  IPDEC1.IAND_6.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_6.I9.MXNA2 IPDEC1.IAND_6.I9.N2 IPDEC1.ADDR[1]
+  IPDEC1.IAND_6.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_6.I9.MXNA3 IPDEC1.IAND_6.I9.N1 NRADDR_A[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_6.I9.MXPA1 IPDEC1.IAND_6.DEC_N IPDEC1.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_6.I9.MXPA2 IPDEC1.IAND_6.DEC_N IPDEC1.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_6.I9.MXPA3 IPDEC1.IAND_6.DEC_N NRADDR_A[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec1.Iand_7.I17.MXNA1 IPDEC1.IAND_7.DEC IPDEC1.IAND_7.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec1.Iand_7.I17.MXPA1 IPDEC1.IAND_7.DEC IPDEC1.IAND_7.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec1.Iand_7.I19.MXNA1 NXPDEC1_A[7] IPDEC1.IAND_7.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec1.Iand_7.I19.MXPA1 NXPDEC1_A[7] IPDEC1.IAND_7.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec1.Iand_7.I9.MXNA1 IPDEC1.IAND_7.DEC_N IPDEC1.ADDR[2]
+  IPDEC1.IAND_7.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_7.I9.MXNA2 IPDEC1.IAND_7.I9.N2 IPDEC1.ADDR[1]
+  IPDEC1.IAND_7.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec1.Iand_7.I9.MXNA3 IPDEC1.IAND_7.I9.N1 IPDEC1.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec1.Iand_7.I9.MXPA1 IPDEC1.IAND_7.DEC_N IPDEC1.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_7.I9.MXPA2 IPDEC1.IAND_7.DEC_N IPDEC1.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec1.Iand_7.I9.MXPA3 IPDEC1.IAND_7.DEC_N IPDEC1.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.I16_0.MXNA1 IPDEC2.ADDR[0] NRADDR_B[0] VSS VPW N11LL_CKT W=0.96U
+  L=0.04U
X_MIpdec2.I16_0.MXPA1 IPDEC2.ADDR[0] NRADDR_B[0] VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIpdec2.I16_1.MXNA1 IPDEC2.ADDR[1] NRADDR_B[1] VSS VPW N11LL_CKT W=0.96U
+  L=0.04U
X_MIpdec2.I16_1.MXPA1 IPDEC2.ADDR[1] NRADDR_B[1] VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIpdec2.I16_2.MXNA1 IPDEC2.ADDR[2] NRADDR_B[2] VSS VPW N11LL_CKT W=0.96U
+  L=0.04U
X_MIpdec2.I16_2.MXPA1 IPDEC2.ADDR[2] NRADDR_B[2] VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIpdec2.Iand_0.I17.MXNA1 IPDEC2.IAND_0.DEC IPDEC2.IAND_0.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_0.I17.MXPA1 IPDEC2.IAND_0.DEC IPDEC2.IAND_0.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_0.I19.MXNA1 NXPDEC1_B[0] IPDEC2.IAND_0.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_0.I19.MXPA1 NXPDEC1_B[0] IPDEC2.IAND_0.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_0.I9.MXNA1 IPDEC2.IAND_0.DEC_N NRADDR_B[2] IPDEC2.IAND_0.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_0.I9.MXNA2 IPDEC2.IAND_0.I9.N2 NRADDR_B[1] IPDEC2.IAND_0.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_0.I9.MXNA3 IPDEC2.IAND_0.I9.N1 NRADDR_B[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_0.I9.MXPA1 IPDEC2.IAND_0.DEC_N NRADDR_B[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_0.I9.MXPA2 IPDEC2.IAND_0.DEC_N NRADDR_B[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_0.I9.MXPA3 IPDEC2.IAND_0.DEC_N NRADDR_B[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_1.I17.MXNA1 IPDEC2.IAND_1.DEC IPDEC2.IAND_1.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_1.I17.MXPA1 IPDEC2.IAND_1.DEC IPDEC2.IAND_1.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_1.I19.MXNA1 NXPDEC1_B[1] IPDEC2.IAND_1.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_1.I19.MXPA1 NXPDEC1_B[1] IPDEC2.IAND_1.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_1.I9.MXNA1 IPDEC2.IAND_1.DEC_N NRADDR_B[2] IPDEC2.IAND_1.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_1.I9.MXNA2 IPDEC2.IAND_1.I9.N2 NRADDR_B[1] IPDEC2.IAND_1.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_1.I9.MXNA3 IPDEC2.IAND_1.I9.N1 IPDEC2.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_1.I9.MXPA1 IPDEC2.IAND_1.DEC_N NRADDR_B[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_1.I9.MXPA2 IPDEC2.IAND_1.DEC_N NRADDR_B[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_1.I9.MXPA3 IPDEC2.IAND_1.DEC_N IPDEC2.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_2.I17.MXNA1 IPDEC2.IAND_2.DEC IPDEC2.IAND_2.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_2.I17.MXPA1 IPDEC2.IAND_2.DEC IPDEC2.IAND_2.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_2.I19.MXNA1 NXPDEC1_B[2] IPDEC2.IAND_2.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_2.I19.MXPA1 NXPDEC1_B[2] IPDEC2.IAND_2.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_2.I9.MXNA1 IPDEC2.IAND_2.DEC_N NRADDR_B[2] IPDEC2.IAND_2.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_2.I9.MXNA2 IPDEC2.IAND_2.I9.N2 IPDEC2.ADDR[1]
+  IPDEC2.IAND_2.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_2.I9.MXNA3 IPDEC2.IAND_2.I9.N1 NRADDR_B[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_2.I9.MXPA1 IPDEC2.IAND_2.DEC_N NRADDR_B[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_2.I9.MXPA2 IPDEC2.IAND_2.DEC_N IPDEC2.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_2.I9.MXPA3 IPDEC2.IAND_2.DEC_N NRADDR_B[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_3.I17.MXNA1 IPDEC2.IAND_3.DEC IPDEC2.IAND_3.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_3.I17.MXPA1 IPDEC2.IAND_3.DEC IPDEC2.IAND_3.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_3.I19.MXNA1 NXPDEC1_B[3] IPDEC2.IAND_3.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_3.I19.MXPA1 NXPDEC1_B[3] IPDEC2.IAND_3.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_3.I9.MXNA1 IPDEC2.IAND_3.DEC_N NRADDR_B[2] IPDEC2.IAND_3.I9.N2
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_3.I9.MXNA2 IPDEC2.IAND_3.I9.N2 IPDEC2.ADDR[1]
+  IPDEC2.IAND_3.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_3.I9.MXNA3 IPDEC2.IAND_3.I9.N1 IPDEC2.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_3.I9.MXPA1 IPDEC2.IAND_3.DEC_N NRADDR_B[2] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_3.I9.MXPA2 IPDEC2.IAND_3.DEC_N IPDEC2.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_3.I9.MXPA3 IPDEC2.IAND_3.DEC_N IPDEC2.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_4.I17.MXNA1 IPDEC2.IAND_4.DEC IPDEC2.IAND_4.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_4.I17.MXPA1 IPDEC2.IAND_4.DEC IPDEC2.IAND_4.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_4.I19.MXNA1 NXPDEC1_B[4] IPDEC2.IAND_4.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_4.I19.MXPA1 NXPDEC1_B[4] IPDEC2.IAND_4.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_4.I9.MXNA1 IPDEC2.IAND_4.DEC_N IPDEC2.ADDR[2]
+  IPDEC2.IAND_4.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_4.I9.MXNA2 IPDEC2.IAND_4.I9.N2 NRADDR_B[1] IPDEC2.IAND_4.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_4.I9.MXNA3 IPDEC2.IAND_4.I9.N1 NRADDR_B[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_4.I9.MXPA1 IPDEC2.IAND_4.DEC_N IPDEC2.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_4.I9.MXPA2 IPDEC2.IAND_4.DEC_N NRADDR_B[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_4.I9.MXPA3 IPDEC2.IAND_4.DEC_N NRADDR_B[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_5.I17.MXNA1 IPDEC2.IAND_5.DEC IPDEC2.IAND_5.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_5.I17.MXPA1 IPDEC2.IAND_5.DEC IPDEC2.IAND_5.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_5.I19.MXNA1 NXPDEC1_B[5] IPDEC2.IAND_5.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_5.I19.MXPA1 NXPDEC1_B[5] IPDEC2.IAND_5.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_5.I9.MXNA1 IPDEC2.IAND_5.DEC_N IPDEC2.ADDR[2]
+  IPDEC2.IAND_5.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_5.I9.MXNA2 IPDEC2.IAND_5.I9.N2 NRADDR_B[1] IPDEC2.IAND_5.I9.N1
+  VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_5.I9.MXNA3 IPDEC2.IAND_5.I9.N1 IPDEC2.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_5.I9.MXPA1 IPDEC2.IAND_5.DEC_N IPDEC2.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_5.I9.MXPA2 IPDEC2.IAND_5.DEC_N NRADDR_B[1] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_5.I9.MXPA3 IPDEC2.IAND_5.DEC_N IPDEC2.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_6.I17.MXNA1 IPDEC2.IAND_6.DEC IPDEC2.IAND_6.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_6.I17.MXPA1 IPDEC2.IAND_6.DEC IPDEC2.IAND_6.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_6.I19.MXNA1 NXPDEC1_B[6] IPDEC2.IAND_6.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_6.I19.MXPA1 NXPDEC1_B[6] IPDEC2.IAND_6.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_6.I9.MXNA1 IPDEC2.IAND_6.DEC_N IPDEC2.ADDR[2]
+  IPDEC2.IAND_6.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_6.I9.MXNA2 IPDEC2.IAND_6.I9.N2 IPDEC2.ADDR[1]
+  IPDEC2.IAND_6.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_6.I9.MXNA3 IPDEC2.IAND_6.I9.N1 NRADDR_B[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_6.I9.MXPA1 IPDEC2.IAND_6.DEC_N IPDEC2.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_6.I9.MXPA2 IPDEC2.IAND_6.DEC_N IPDEC2.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_6.I9.MXPA3 IPDEC2.IAND_6.DEC_N NRADDR_B[0] VDDPE VNWP P11LL_CKT
+  W=0.575U L=0.04U
X_MIpdec2.Iand_7.I17.MXNA1 IPDEC2.IAND_7.DEC IPDEC2.IAND_7.DEC_N VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIpdec2.Iand_7.I17.MXPA1 IPDEC2.IAND_7.DEC IPDEC2.IAND_7.DEC_N VDDPE VNWP
+  P11LL_CKT W=1.95U L=0.04U
X_MIpdec2.Iand_7.I19.MXNA1 NXPDEC1_B[7] IPDEC2.IAND_7.DEC VSS VPW N11LL_CKT
+  W=3.72U L=0.04U
X_MIpdec2.Iand_7.I19.MXPA1 NXPDEC1_B[7] IPDEC2.IAND_7.DEC VDDPE VNWP P11LL_CKT
+  W=7.44U L=0.04U
X_MIpdec2.Iand_7.I9.MXNA1 IPDEC2.IAND_7.DEC_N IPDEC2.ADDR[2]
+  IPDEC2.IAND_7.I9.N2 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_7.I9.MXNA2 IPDEC2.IAND_7.I9.N2 IPDEC2.ADDR[1]
+  IPDEC2.IAND_7.I9.N1 VPW N11LL_CKT W=0.845U L=0.04U
X_MIpdec2.Iand_7.I9.MXNA3 IPDEC2.IAND_7.I9.N1 IPDEC2.ADDR[0] VSS VPW N11LL_CKT
+  W=0.845U L=0.04U
X_MIpdec2.Iand_7.I9.MXPA1 IPDEC2.IAND_7.DEC_N IPDEC2.ADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_7.I9.MXPA2 IPDEC2.IAND_7.DEC_N IPDEC2.ADDR[1] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIpdec2.Iand_7.I9.MXPA3 IPDEC2.IAND_7.DEC_N IPDEC2.ADDR[0] VDDPE VNWP
+  P11LL_CKT W=0.575U L=0.04U
X_MIph2lats_dp_1va.I12.MXNA1 IPH2LATS_DP_1VA.CLK_CTL NCLK_CTL_A VSS VPW
+  N11LL_CKT W=2.32U L=0.04U
X_MIph2lats_dp_1va.I12.MXPA1 IPH2LATS_DP_1VA.CLK_CTL NCLK_CTL_A VDDPE VNWP
+  P11LL_CKT W=3.44U L=0.04U
X_MIph2lats_dp_1va.I13.MXNA1 DFTRAMBYP_BUF_A IPH2LATS_DP_1VA.NET289 VSS VPW
+  N11LL_CKT W=3.2U L=0.04U
X_MIph2lats_dp_1va.I13.MXPA1 DFTRAMBYP_BUF_A IPH2LATS_DP_1VA.NET289 VDDPE VNWP
+  P11LL_CKT W=3.6U L=0.04U
X_MIph2lats_dp_1va.I15.MXNA1 IPH2LATS_DP_1VA.NET289 DFTRAMBYP VSS VPW
+  N11LL_CKT W=0.595U L=0.04U
X_MIph2lats_dp_1va.I15.MXPA1 IPH2LATS_DP_1VA.NET289 DFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.825U L=0.04U
X_MIph2lats_dp_1va.I17.MXNA1 IPH2LATS_DP_1VA.NET331 TENA VSS VPW N11LL_CKT
+  W=0.24U L=0.04U
X_MIph2lats_dp_1va.I17.MXPA1 IPH2LATS_DP_1VA.NET331 TENA VDDPE VNWP P11LL_CKT
+  W=0.355U L=0.04U
X_MIph2lats_dp_1va.I18.MXNA1 IPH2LATS_DP_1VA.TEN_I IPH2LATS_DP_1VA.NET331 VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.I18.MXPA1 IPH2LATS_DP_1VA.TEN_I IPH2LATS_DP_1VA.NET331
+  VDDPE VNWP P11LL_CKT W=1.48U L=0.04U
X_MIph2lats_dp_1va.I19.MXNA1 NWTE_A IPH2LATS_DP_1VA.NET193 VSS VPW N11LL_CKT
+  W=1.42U L=0.04U
X_MIph2lats_dp_1va.I19.MXNA2 NWTE_A DFTRAMBYP_P2_A VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIph2lats_dp_1va.I19.MXPA1 NWTE_A IPH2LATS_DP_1VA.NET193
+  IPH2LATS_DP_1VA.I19.P1 VNWP P11LL_CKT W=2.74U L=0.04U
X_MIph2lats_dp_1va.I19.MXPA2 IPH2LATS_DP_1VA.I19.P1 DFTRAMBYP_P2_A VDDPE VNWP
+  P11LL_CKT W=2.74U L=0.04U
X_MIph2lats_dp_1va.I20.MXNA1 IPH2LATS_DP_1VA.NET193 NGWE_A VSS VPW N11LL_CKT
+  W=0.355U L=0.04U
X_MIph2lats_dp_1va.I20.MXNA2 IPH2LATS_DP_1VA.NET193 IPH2LATS_DP_1VA.NET313 VSS
+  VPW N11LL_CKT W=0.355U L=0.04U
X_MIph2lats_dp_1va.I20.MXPA1 IPH2LATS_DP_1VA.NET193 NGWE_A
+  IPH2LATS_DP_1VA.I20.P1 VNWP P11LL_CKT W=1.37U L=0.04U
X_MIph2lats_dp_1va.I20.MXPA2 IPH2LATS_DP_1VA.I20.P1 IPH2LATS_DP_1VA.NET313
+  VDDPE VNWP P11LL_CKT W=1.37U L=0.04U
X_MIph2lats_dp_1va.I21.MXNA1 IPH2LATS_DP_1VA.NET313 WT VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIph2lats_dp_1va.I21.MXPA1 IPH2LATS_DP_1VA.NET313 WT VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIph2lats_dp_1va.I23.MXNA1 IPH2LATS_DP_1VA.NET200 IPH2LATS_DP_1VA.NET295 VSS
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIph2lats_dp_1va.I23.MXNA2 IPH2LATS_DP_1VA.NET200 NGWE_A VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIph2lats_dp_1va.I23.MXPA1 IPH2LATS_DP_1VA.NET200 IPH2LATS_DP_1VA.NET295
+  IPH2LATS_DP_1VA.I23.P1 VNWP P11LL_CKT W=0.455U L=0.04U
X_MIph2lats_dp_1va.I23.MXPA2 IPH2LATS_DP_1VA.I23.P1 NGWE_A VDDPE VNWP
+  P11LL_CKT W=0.455U L=0.04U
X_MIph2lats_dp_1va.I24.MXNA1 NGWE_WT_A IPH2LATS_DP_1VA.NET200 VSS VPW
+  N11LL_CKT W=1.13U L=0.04U
X_MIph2lats_dp_1va.I24.MXPA1 NGWE_WT_A IPH2LATS_DP_1VA.NET200 VDDPE VNWP
+  P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.I25.MXNA1 IPH2LATS_DP_1VA.NET295 NWTE_A VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIph2lats_dp_1va.I25.MXPA1 IPH2LATS_DP_1VA.NET295 NWTE_A VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIph2lats_dp_1va.I28_0.MXNA1 IPH2LATS_DP_1VA.NET271[1]
+  IPH2LATS_DP_1VA.NET265[1] VSS VPW N11LL_CKT W=0.315U L=0.04U
X_MIph2lats_dp_1va.I28_0.MXPA1 IPH2LATS_DP_1VA.NET271[1]
+  IPH2LATS_DP_1VA.NET265[1] VDDPE VNWP P11LL_CKT W=0.41U L=0.04U
X_MIph2lats_dp_1va.I28_1.MXNA1 IPH2LATS_DP_1VA.NET271[0]
+  IPH2LATS_DP_1VA.NET265[0] VSS VPW N11LL_CKT W=0.315U L=0.04U
X_MIph2lats_dp_1va.I28_1.MXPA1 IPH2LATS_DP_1VA.NET271[0]
+  IPH2LATS_DP_1VA.NET265[0] VDDPE VNWP P11LL_CKT W=0.41U L=0.04U
X_MIph2lats_dp_1va.I29_0.MXNA1 IPH2LATS_DP_1VA.NET265[1]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1va.I29_0.MXPA1 IPH2LATS_DP_1VA.NET265[1]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1va.I29_1.MXNA1 IPH2LATS_DP_1VA.NET265[0]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1va.I29_1.MXPA1 IPH2LATS_DP_1VA.NET265[0]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_0.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_0.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.I60.MXNA1 NCADDR_A[0]
+  IPH2LATS_DP_1VA.IADDR1_0.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.I60.MXPA1 NCADDR_A[0]
+  IPH2LATS_DP_1VA.IADDR1_0.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_0.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_0.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_0.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_0.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] IPH2LATS_DP_1VA.IADDR1_0.NCLK
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I62.MXNA1 CAYA[0]
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I62.MXPA1 CAYA[0]
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] IPH2LATS_DP_1VA.IADDR1_0.NCLK
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND
+  CAA[0] IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND
+  TCAA[0] IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND
+  TCAA[0] IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.ND
+  CAA[0] IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_0.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_0.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_1.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_1.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.I60.MXNA1 NCADDR_A[1]
+  IPH2LATS_DP_1VA.IADDR1_1.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.I60.MXPA1 NCADDR_A[1]
+  IPH2LATS_DP_1VA.IADDR1_1.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_1.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_1.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_1.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_1.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] IPH2LATS_DP_1VA.IADDR1_1.NCLK
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I62.MXNA1 CAYA[1]
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I62.MXPA1 CAYA[1]
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] IPH2LATS_DP_1VA.IADDR1_1.NCLK
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND
+  CAA[1] IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND
+  TCAA[1] IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND
+  TCAA[1] IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.ND
+  CAA[1] IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_1.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_1.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_10.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_10.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.I60.MXNA1 NRADDR_A[6]
+  IPH2LATS_DP_1VA.IADDR1_10.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.I60.MXPA1 NRADDR_A[6]
+  IPH2LATS_DP_1VA.IADDR1_10.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NDY
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NDY
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I50.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_10.Q_INT IPH2LATS_DP_1VA.NRADDR_INT_P2[6] VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I50.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_10.Q_INT IPH2LATS_DP_1VA.NRADDR_INT_P2[6] VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_10.Q_INT
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[6] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_10.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[6] IPH2LATS_DP_1VA.IADDR1_10.NCLK
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I62.MXNA1 RAYA[6]
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I62.MXPA1 RAYA[6]
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[6] IPH2LATS_DP_1VA.IADDR1_10.NCLK
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[6] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXN1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND RAA[6]
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXN2
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND TRAA[6]
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXN5
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXN6
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.N2 IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXP1
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND TRAA[6]
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXP3
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.ND RAA[6]
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXP4
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.P1 IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_10.Iaddrlat.MXP5
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_10.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_11.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_11.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.I60.MXNA1 NRADDR_A[7]
+  IPH2LATS_DP_1VA.IADDR1_11.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.I60.MXPA1 NRADDR_A[7]
+  IPH2LATS_DP_1VA.IADDR1_11.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NDY
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NDY
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I50.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_11.Q_INT IPH2LATS_DP_1VA.NRADDR_INT_P2[7] VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I50.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_11.Q_INT IPH2LATS_DP_1VA.NRADDR_INT_P2[7] VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_11.Q_INT
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[7] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_11.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[7] IPH2LATS_DP_1VA.IADDR1_11.NCLK
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I62.MXNA1 RAYA[7]
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I62.MXPA1 RAYA[7]
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[7] IPH2LATS_DP_1VA.IADDR1_11.NCLK
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[7] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXN1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND RAA[7]
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXN2
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND TRAA[7]
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXN5
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXN6
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.N2 IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXP1
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND TRAA[7]
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXP3
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.ND RAA[7]
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXP4
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.P1 IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_11.Iaddrlat.MXP5
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_11.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_12.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_12.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.I60.MXNA1 IPH2LATS_DP_1VA.NRADDR_P2[8]
+  IPH2LATS_DP_1VA.IADDR1_12.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.I60.MXPA1 IPH2LATS_DP_1VA.NRADDR_P2[8]
+  IPH2LATS_DP_1VA.IADDR1_12.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NDY
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NDY
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I50.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_12.Q_INT IPH2LATS_DP_1VA.NRADDR_INT_P2[8] VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I50.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_12.Q_INT IPH2LATS_DP_1VA.NRADDR_INT_P2[8] VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_12.Q_INT
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[8] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_12.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[8] IPH2LATS_DP_1VA.IADDR1_12.NCLK
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I62.MXNA1 RAYA[8]
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I62.MXPA1 RAYA[8]
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[8] IPH2LATS_DP_1VA.IADDR1_12.NCLK
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[8] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXN1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND RAA[8]
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXN2
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND TRAA[8]
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXN5
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXN6
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.N2 IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXP1
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND TRAA[8]
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXP3
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.ND RAA[8]
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXP4
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.P1 IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_12.Iaddrlat.MXP5
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_12.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_2.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_2.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.I60.MXNA1 IPH2LATS_DP_1VA.NCADDR_P2[2]
+  IPH2LATS_DP_1VA.IADDR1_2.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.I60.MXPA1 IPH2LATS_DP_1VA.NCADDR_P2[2]
+  IPH2LATS_DP_1VA.IADDR1_2.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_2.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_2.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_2.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_2.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] IPH2LATS_DP_1VA.IADDR1_2.NCLK
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I62.MXNA1 CAYA[2]
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I62.MXPA1 CAYA[2]
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] IPH2LATS_DP_1VA.IADDR1_2.NCLK
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[2] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND
+  CAA[2] IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND
+  TCAA[2] IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND
+  TCAA[2] IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.ND
+  CAA[2] IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_2.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_2.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_3.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_3.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.I60.MXNA1 IPH2LATS_DP_1VA.NCADDR_P2[3]
+  IPH2LATS_DP_1VA.IADDR1_3.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.I60.MXPA1 IPH2LATS_DP_1VA.NCADDR_P2[3]
+  IPH2LATS_DP_1VA.IADDR1_3.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_3.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_3.Q_INT
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_3.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_3.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] IPH2LATS_DP_1VA.IADDR1_3.NCLK
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I62.MXNA1 CAYA[3]
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I62.MXPA1 CAYA[3]
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] IPH2LATS_DP_1VA.IADDR1_3.NCLK
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[3] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND
+  CAA[3] IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND
+  TCAA[3] IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND
+  TCAA[3] IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.ND
+  CAA[3] IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_3.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_3.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_4.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_4.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.I60.MXNA1 NRADDR_A[0]
+  IPH2LATS_DP_1VA.IADDR1_4.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.I60.MXPA1 NRADDR_A[0]
+  IPH2LATS_DP_1VA.IADDR1_4.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_4.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[0] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_4.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[0] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_4.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[0] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_4.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[0] IPH2LATS_DP_1VA.IADDR1_4.NCLK
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I62.MXNA1 RAYA[0]
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I62.MXPA1 RAYA[0]
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[0] IPH2LATS_DP_1VA.IADDR1_4.NCLK
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[0] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND
+  RAA[0] IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND
+  TRAA[0] IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND
+  TRAA[0] IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.ND
+  RAA[0] IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_4.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_4.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_5.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_5.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.I60.MXNA1 NRADDR_A[1]
+  IPH2LATS_DP_1VA.IADDR1_5.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.I60.MXPA1 NRADDR_A[1]
+  IPH2LATS_DP_1VA.IADDR1_5.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_5.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[1] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_5.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[1] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_5.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[1] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_5.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[1] IPH2LATS_DP_1VA.IADDR1_5.NCLK
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I62.MXNA1 RAYA[1]
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I62.MXPA1 RAYA[1]
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[1] IPH2LATS_DP_1VA.IADDR1_5.NCLK
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[1] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND
+  RAA[1] IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND
+  TRAA[1] IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND
+  TRAA[1] IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.ND
+  RAA[1] IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_5.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_5.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_6.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_6.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.I60.MXNA1 NRADDR_A[2]
+  IPH2LATS_DP_1VA.IADDR1_6.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.I60.MXPA1 NRADDR_A[2]
+  IPH2LATS_DP_1VA.IADDR1_6.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_6.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[2] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_6.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[2] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_6.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[2] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_6.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[2] IPH2LATS_DP_1VA.IADDR1_6.NCLK
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I62.MXNA1 RAYA[2]
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I62.MXPA1 RAYA[2]
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[2] IPH2LATS_DP_1VA.IADDR1_6.NCLK
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[2] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND
+  RAA[2] IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND
+  TRAA[2] IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND
+  TRAA[2] IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.ND
+  RAA[2] IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_6.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_6.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_7.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_7.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.I60.MXNA1 NRADDR_A[3]
+  IPH2LATS_DP_1VA.IADDR1_7.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.I60.MXPA1 NRADDR_A[3]
+  IPH2LATS_DP_1VA.IADDR1_7.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_7.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[3] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_7.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[3] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_7.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[3] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_7.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[3] IPH2LATS_DP_1VA.IADDR1_7.NCLK
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I62.MXNA1 RAYA[3]
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I62.MXPA1 RAYA[3]
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[3] IPH2LATS_DP_1VA.IADDR1_7.NCLK
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[3] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND
+  RAA[3] IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND
+  TRAA[3] IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND
+  TRAA[3] IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.ND
+  RAA[3] IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_7.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_7.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_8.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_8.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.I60.MXNA1 NRADDR_A[4]
+  IPH2LATS_DP_1VA.IADDR1_8.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.I60.MXPA1 NRADDR_A[4]
+  IPH2LATS_DP_1VA.IADDR1_8.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_8.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[4] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_8.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[4] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_8.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[4] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_8.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[4] IPH2LATS_DP_1VA.IADDR1_8.NCLK
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I62.MXNA1 RAYA[4]
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I62.MXPA1 RAYA[4]
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[4] IPH2LATS_DP_1VA.IADDR1_8.NCLK
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[4] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND
+  RAA[4] IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND
+  TRAA[4] IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND
+  TRAA[4] IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.ND
+  RAA[4] IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_8.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_8.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.I49.MXNA1 IPH2LATS_DP_1VA.IADDR1_9.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.I49.MXPA1 IPH2LATS_DP_1VA.IADDR1_9.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.I60.MXNA1 NRADDR_A[5]
+  IPH2LATS_DP_1VA.IADDR1_9.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.I60.MXPA1 NRADDR_A[5]
+  IPH2LATS_DP_1VA.IADDR1_9.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.IDY
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.I0.N1 DFTRAMBYP_BUF_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NDY IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NDY DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VA.IADDR1_9.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[5] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VA.IADDR1_9.Q_INT
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[5] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.I55.N1 IPH2LATS_DP_1VA.IADDR1_9.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[5] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.I55.P1 IPH2LATS_DP_1VA.IADDR1_9.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[5] IPH2LATS_DP_1VA.IADDR1_9.NCLK
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NSEL IPH2LATS_DP_1VA.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I62.MXNA1 RAYA[5]
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I62.MXPA1 RAYA[5]
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.IDY IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[5] IPH2LATS_DP_1VA.IADDR1_9.NCLK
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VA.NRADDR_INT_P2[5] IPH2LATS_DP_1VA.CLK_CTL
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXN1 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND
+  RAA[5] IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXN2 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND
+  TRAA[5] IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXN5 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.N1
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXN6 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXP1 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND
+  TRAA[5] IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXP3 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.ND
+  RAA[5] IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXP4 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1va.Iaddr1_9.Iaddrlat.MXP5 IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.P2
+  IPH2LATS_DP_1VA.IADDR1_9.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_0.MXNA1 IPH2LATS_DP_1VA.CADDR_P2[0]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_0.MXPA1 IPH2LATS_DP_1VA.CADDR_P2[0]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[0] VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_1.MXNA1 IPH2LATS_DP_1VA.CADDR_P2[1]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_1.MXPA1 IPH2LATS_DP_1VA.CADDR_P2[1]
+  IPH2LATS_DP_1VA.NCADDR_INT_P2[1] VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_10.MXNA1 RADDR_A[8] IPH2LATS_DP_1VA.NRADDR_INT_P2[8]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_10.MXPA1 RADDR_A[8] IPH2LATS_DP_1VA.NRADDR_INT_P2[8]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_2.MXNA1 RADDR_A[0] IPH2LATS_DP_1VA.NRADDR_INT_P2[0]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_2.MXPA1 RADDR_A[0] IPH2LATS_DP_1VA.NRADDR_INT_P2[0]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_3.MXNA1 RADDR_A[1] IPH2LATS_DP_1VA.NRADDR_INT_P2[1]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_3.MXPA1 RADDR_A[1] IPH2LATS_DP_1VA.NRADDR_INT_P2[1]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_4.MXNA1 RADDR_A[2] IPH2LATS_DP_1VA.NRADDR_INT_P2[2]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_4.MXPA1 RADDR_A[2] IPH2LATS_DP_1VA.NRADDR_INT_P2[2]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_5.MXNA1 RADDR_A[3] IPH2LATS_DP_1VA.NRADDR_INT_P2[3]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_5.MXPA1 RADDR_A[3] IPH2LATS_DP_1VA.NRADDR_INT_P2[3]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_6.MXNA1 RADDR_A[4] IPH2LATS_DP_1VA.NRADDR_INT_P2[4]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_6.MXPA1 RADDR_A[4] IPH2LATS_DP_1VA.NRADDR_INT_P2[4]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_7.MXNA1 RADDR_A[5] IPH2LATS_DP_1VA.NRADDR_INT_P2[5]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_7.MXPA1 RADDR_A[5] IPH2LATS_DP_1VA.NRADDR_INT_P2[5]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_8.MXNA1 RADDR_A[6] IPH2LATS_DP_1VA.NRADDR_INT_P2[6]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_8.MXPA1 RADDR_A[6] IPH2LATS_DP_1VA.NRADDR_INT_P2[6]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_9.MXNA1 RADDR_A[7] IPH2LATS_DP_1VA.NRADDR_INT_P2[7]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1va.Iaddrq_9.MXPA1 RADDR_A[7] IPH2LATS_DP_1VA.NRADDR_INT_P2[7]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1va.Icaddrq_0.MXNA1 CADDR_A[2] IPH2LATS_DP_1VA.NET271[1] VSS
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIph2lats_dp_1va.Icaddrq_0.MXPA1 CADDR_A[2] IPH2LATS_DP_1VA.NET271[1] VDDPE
+  VNWP P11LL_CKT W=1.1U L=0.04U
X_MIph2lats_dp_1va.Icaddrq_1.MXNA1 CADDR_A[3] IPH2LATS_DP_1VA.NET271[0] VSS
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIph2lats_dp_1va.Icaddrq_1.MXPA1 CADDR_A[3] IPH2LATS_DP_1VA.NET271[0] VDDPE
+  VNWP P11LL_CKT W=1.1U L=0.04U
X_MIph2lats_dp_1va.Icen.I49.MXNA1 IPH2LATS_DP_1VA.ICEN.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Icen.I49.MXPA1 IPH2LATS_DP_1VA.ICEN.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I0.MXNA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.IDY IPH2LATS_DP_1VA.ICEN.ICTLLAT.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I0.MXNA2 IPH2LATS_DP_1VA.ICEN.ICTLLAT.I0.N1
+  DFTRAMBYP_BUF_A VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I0.MXPA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I0.MXPA2 IPH2LATS_DP_1VA.ICEN.ICTLLAT.NDY
+  DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I50.MXNA1 NCE_A IPH2LATS_DP_1VA.ICEN.NQ_INT
+  VSS VPW N11LL_CKT W=2U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I50.MXPA1 NCE_A IPH2LATS_DP_1VA.ICEN.NQ_INT
+  VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I55.MXNA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.I55.N1
+  NCE_A VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I55.MXNOE IPH2LATS_DP_1VA.ICEN.NQ_INT
+  IPH2LATS_DP_1VA.CLK_CTL IPH2LATS_DP_1VA.ICEN.ICTLLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I55.MXPA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.I55.P1
+  NCE_A VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I55.MXPOEN IPH2LATS_DP_1VA.ICEN.NQ_INT
+  IPH2LATS_DP_1VA.ICEN.NCLK IPH2LATS_DP_1VA.ICEN.ICTLLAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I57.MXNA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I57.MXPA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I62.MXNA1 CENYA
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I62.MXPA1 CENYA
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I63.MXNA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I63.MXPA1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I65.MXNOE IPH2LATS_DP_1VA.ICEN.NQ_INT
+  IPH2LATS_DP_1VA.ICEN.NCLK IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND VPW N11LL_CKT
+  W=1.34U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.I65.MXPOEN IPH2LATS_DP_1VA.ICEN.NQ_INT
+  IPH2LATS_DP_1VA.CLK_CTL IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND VNWP P11LL_CKT
+  W=1.8U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXN1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND CENA
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.N2 VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXN2 IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND TCENA
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.N1 VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXN5 IPH2LATS_DP_1VA.ICEN.ICTLLAT.N1
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.NSEL VSS VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXN6 IPH2LATS_DP_1VA.ICEN.ICTLLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXP1 IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND TCENA
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.P1 VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXP3 IPH2LATS_DP_1VA.ICEN.ICTLLAT.ND CENA
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.P2 VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXP4 IPH2LATS_DP_1VA.ICEN.ICTLLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1va.Icen.Ictllat.MXP5 IPH2LATS_DP_1VA.ICEN.ICTLLAT.P2
+  IPH2LATS_DP_1VA.ICEN.ICTLLAT.NSEL VDDPE VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1va.Idft.I49.MXNA1 IPH2LATS_DP_1VA.IDFT.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Idft.I49.MXPA1 IPH2LATS_DP_1VA.IDFT.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I47.MXNA1 IPH2LATS_DP_1VA.IDFT.IDFTLAT.ND
+  DFTRAMBYP VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I47.MXPA1 IPH2LATS_DP_1VA.IDFT.IDFTLAT.ND
+  DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I48.MXNOE IPH2LATS_DP_1VA.IDFT.NQ_INT
+  IPH2LATS_DP_1VA.IDFT.NCLK IPH2LATS_DP_1VA.IDFT.IDFTLAT.ND VPW N11LL_CKT
+  W=0.57U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I48.MXPOEN IPH2LATS_DP_1VA.IDFT.NQ_INT
+  IPH2LATS_DP_1VA.CLK_CTL IPH2LATS_DP_1VA.IDFT.IDFTLAT.ND VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I50.MXNA1 DFTRAMBYP_P2_A
+  IPH2LATS_DP_1VA.IDFT.NQ_INT VSS VPW N11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I50.MXPA1 DFTRAMBYP_P2_A
+  IPH2LATS_DP_1VA.IDFT.NQ_INT VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I55.MXNA1 IPH2LATS_DP_1VA.IDFT.IDFTLAT.I55.N1
+  DFTRAMBYP_P2_A VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I55.MXNOE IPH2LATS_DP_1VA.IDFT.NQ_INT
+  IPH2LATS_DP_1VA.CLK_CTL IPH2LATS_DP_1VA.IDFT.IDFTLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I55.MXPA1 IPH2LATS_DP_1VA.IDFT.IDFTLAT.I55.P1
+  DFTRAMBYP_P2_A VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Idft.Idftlat.I55.MXPOEN IPH2LATS_DP_1VA.IDFT.NQ_INT
+  IPH2LATS_DP_1VA.IDFT.NCLK IPH2LATS_DP_1VA.IDFT.IDFTLAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Igwen.I49.MXNA1 IPH2LATS_DP_1VA.IGWEN.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Igwen.I49.MXPA1 IPH2LATS_DP_1VA.IGWEN.NCLK
+  IPH2LATS_DP_1VA.CLK_CTL VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I0.MXNA1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.IDY IPH2LATS_DP_1VA.IGWEN.ICTLLAT.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I0.MXNA2 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.I0.N1
+  DFTRAMBYP_BUF_A VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I0.MXPA1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I0.MXPA2 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NDY
+  DFTRAMBYP_BUF_A VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I50.MXNA1 NGWE_A IPH2LATS_DP_1VA.IGWEN.NQ_INT
+  VSS VPW N11LL_CKT W=2U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I50.MXPA1 NGWE_A IPH2LATS_DP_1VA.IGWEN.NQ_INT
+  VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I55.MXNA1
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.I55.N1 NGWE_A VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I55.MXNOE IPH2LATS_DP_1VA.IGWEN.NQ_INT
+  IPH2LATS_DP_1VA.CLK_CTL IPH2LATS_DP_1VA.IGWEN.ICTLLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I55.MXPA1
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.I55.P1 NGWE_A VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I55.MXPOEN IPH2LATS_DP_1VA.IGWEN.NQ_INT
+  IPH2LATS_DP_1VA.IGWEN.NCLK IPH2LATS_DP_1VA.IGWEN.ICTLLAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I57.MXNA1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I57.MXPA1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I62.MXNA1 GWENYA
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I62.MXPA1 GWENYA
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I63.MXNA1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I63.MXPA1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I65.MXNOE IPH2LATS_DP_1VA.IGWEN.NQ_INT
+  IPH2LATS_DP_1VA.IGWEN.NCLK IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND VPW N11LL_CKT
+  W=1.34U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.I65.MXPOEN IPH2LATS_DP_1VA.IGWEN.NQ_INT
+  IPH2LATS_DP_1VA.CLK_CTL IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND VNWP P11LL_CKT
+  W=1.8U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXN1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND GWENA
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.N2 VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXN2 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND TGWENA
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.N1 VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXN5 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.N1
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NSEL VSS VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXN6 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.N2
+  IPH2LATS_DP_1VA.TEN_I VSS VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXP1 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND TGWENA
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.P1 VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXP3 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.ND GWENA
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.P2 VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXP4 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.P1
+  IPH2LATS_DP_1VA.TEN_I VDDPE VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1va.Igwen.Ictllat.MXP5 IPH2LATS_DP_1VA.IGWEN.ICTLLAT.P2
+  IPH2LATS_DP_1VA.IGWEN.ICTLLAT.NSEL VDDPE VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1va.Ilogicgen.Ilogicgen.MXN0 IPH2LATS_DP_1VA.ZERO
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEB VSS VPW N11LL_CKT W=0.51U L=0.04U
X_MIph2lats_dp_1va.Ilogicgen.Ilogicgen.MXN1
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEA
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEA VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIph2lats_dp_1va.Ilogicgen.Ilogicgen.MXN2
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEA
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEB VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIph2lats_dp_1va.Ilogicgen.Ilogicgen.MXP1
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEB
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=0.39U
+  L=0.04U
X_MIph2lats_dp_1va.Ilogicgen.Ilogicgen.MXP4 IPH2LATS_DP_1VA.ONE
+  IPH2LATS_DP_1VA.ILOGICGEN.ILOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=1U L=0.04U
X_MIph2lats_dp_1va.MXN_try LOG0 IPH2LATS_DP_1VA.ONE VSS VPW N11LL_CKT W=3.84U
+  L=0.04U
X_MIph2lats_dp_1va.MXP0 LOG1 IPH2LATS_DP_1VA.ZERO VDDPE VNWP P11LL_CKT W=1.92U
+  L=0.04U
X_MIph2lats_dp_1vb.I12.MXNA1 IPH2LATS_DP_1VB.CLK_CTL NCLK_CTL_B VSS VPW
+  N11LL_CKT W=2.32U L=0.04U
X_MIph2lats_dp_1vb.I12.MXPA1 IPH2LATS_DP_1VB.CLK_CTL NCLK_CTL_B VDDPE VNWP
+  P11LL_CKT W=3.44U L=0.04U
X_MIph2lats_dp_1vb.I13.MXNA1 DFTRAMBYP_BUF_B IPH2LATS_DP_1VB.NET289 VSS VPW
+  N11LL_CKT W=3.2U L=0.04U
X_MIph2lats_dp_1vb.I13.MXPA1 DFTRAMBYP_BUF_B IPH2LATS_DP_1VB.NET289 VDDPE VNWP
+  P11LL_CKT W=3.6U L=0.04U
X_MIph2lats_dp_1vb.I15.MXNA1 IPH2LATS_DP_1VB.NET289 DFTRAMBYP VSS VPW
+  N11LL_CKT W=0.595U L=0.04U
X_MIph2lats_dp_1vb.I15.MXPA1 IPH2LATS_DP_1VB.NET289 DFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.825U L=0.04U
X_MIph2lats_dp_1vb.I17.MXNA1 IPH2LATS_DP_1VB.NET331 TENB VSS VPW N11LL_CKT
+  W=0.24U L=0.04U
X_MIph2lats_dp_1vb.I17.MXPA1 IPH2LATS_DP_1VB.NET331 TENB VDDPE VNWP P11LL_CKT
+  W=0.355U L=0.04U
X_MIph2lats_dp_1vb.I18.MXNA1 IPH2LATS_DP_1VB.TEN_I IPH2LATS_DP_1VB.NET331 VSS
+  VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.I18.MXPA1 IPH2LATS_DP_1VB.TEN_I IPH2LATS_DP_1VB.NET331
+  VDDPE VNWP P11LL_CKT W=1.48U L=0.04U
X_MIph2lats_dp_1vb.I19.MXNA1 NWTE_B IPH2LATS_DP_1VB.NET193 VSS VPW N11LL_CKT
+  W=1.42U L=0.04U
X_MIph2lats_dp_1vb.I19.MXNA2 NWTE_B DFTRAMBYP_P2_B VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIph2lats_dp_1vb.I19.MXPA1 NWTE_B IPH2LATS_DP_1VB.NET193
+  IPH2LATS_DP_1VB.I19.P1 VNWP P11LL_CKT W=2.74U L=0.04U
X_MIph2lats_dp_1vb.I19.MXPA2 IPH2LATS_DP_1VB.I19.P1 DFTRAMBYP_P2_B VDDPE VNWP
+  P11LL_CKT W=2.74U L=0.04U
X_MIph2lats_dp_1vb.I20.MXNA1 IPH2LATS_DP_1VB.NET193 NGWE_B VSS VPW N11LL_CKT
+  W=0.355U L=0.04U
X_MIph2lats_dp_1vb.I20.MXNA2 IPH2LATS_DP_1VB.NET193 IPH2LATS_DP_1VB.NET313 VSS
+  VPW N11LL_CKT W=0.355U L=0.04U
X_MIph2lats_dp_1vb.I20.MXPA1 IPH2LATS_DP_1VB.NET193 NGWE_B
+  IPH2LATS_DP_1VB.I20.P1 VNWP P11LL_CKT W=1.37U L=0.04U
X_MIph2lats_dp_1vb.I20.MXPA2 IPH2LATS_DP_1VB.I20.P1 IPH2LATS_DP_1VB.NET313
+  VDDPE VNWP P11LL_CKT W=1.37U L=0.04U
X_MIph2lats_dp_1vb.I21.MXNA1 IPH2LATS_DP_1VB.NET313 WT VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIph2lats_dp_1vb.I21.MXPA1 IPH2LATS_DP_1VB.NET313 WT VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIph2lats_dp_1vb.I23.MXNA1 IPH2LATS_DP_1VB.NET200 IPH2LATS_DP_1VB.NET295 VSS
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIph2lats_dp_1vb.I23.MXNA2 IPH2LATS_DP_1VB.NET200 NGWE_B VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIph2lats_dp_1vb.I23.MXPA1 IPH2LATS_DP_1VB.NET200 IPH2LATS_DP_1VB.NET295
+  IPH2LATS_DP_1VB.I23.P1 VNWP P11LL_CKT W=0.455U L=0.04U
X_MIph2lats_dp_1vb.I23.MXPA2 IPH2LATS_DP_1VB.I23.P1 NGWE_B VDDPE VNWP
+  P11LL_CKT W=0.455U L=0.04U
X_MIph2lats_dp_1vb.I24.MXNA1 NGWE_WT_B IPH2LATS_DP_1VB.NET200 VSS VPW
+  N11LL_CKT W=1.13U L=0.04U
X_MIph2lats_dp_1vb.I24.MXPA1 NGWE_WT_B IPH2LATS_DP_1VB.NET200 VDDPE VNWP
+  P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.I25.MXNA1 IPH2LATS_DP_1VB.NET295 NWTE_B VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIph2lats_dp_1vb.I25.MXPA1 IPH2LATS_DP_1VB.NET295 NWTE_B VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIph2lats_dp_1vb.I28_0.MXNA1 IPH2LATS_DP_1VB.NET271[1]
+  IPH2LATS_DP_1VB.NET265[1] VSS VPW N11LL_CKT W=0.315U L=0.04U
X_MIph2lats_dp_1vb.I28_0.MXPA1 IPH2LATS_DP_1VB.NET271[1]
+  IPH2LATS_DP_1VB.NET265[1] VDDPE VNWP P11LL_CKT W=0.41U L=0.04U
X_MIph2lats_dp_1vb.I28_1.MXNA1 IPH2LATS_DP_1VB.NET271[0]
+  IPH2LATS_DP_1VB.NET265[0] VSS VPW N11LL_CKT W=0.315U L=0.04U
X_MIph2lats_dp_1vb.I28_1.MXPA1 IPH2LATS_DP_1VB.NET271[0]
+  IPH2LATS_DP_1VB.NET265[0] VDDPE VNWP P11LL_CKT W=0.41U L=0.04U
X_MIph2lats_dp_1vb.I29_0.MXNA1 IPH2LATS_DP_1VB.NET265[1]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1vb.I29_0.MXPA1 IPH2LATS_DP_1VB.NET265[1]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1vb.I29_1.MXNA1 IPH2LATS_DP_1VB.NET265[0]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] VSS VPW N11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1vb.I29_1.MXPA1 IPH2LATS_DP_1VB.NET265[0]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_0.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_0.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.I60.MXNA1 NCADDR_B[0]
+  IPH2LATS_DP_1VB.IADDR1_0.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.I60.MXPA1 NCADDR_B[0]
+  IPH2LATS_DP_1VB.IADDR1_0.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_0.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_0.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_0.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_0.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] IPH2LATS_DP_1VB.IADDR1_0.NCLK
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I62.MXNA1 CAYB[0]
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I62.MXPA1 CAYB[0]
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] IPH2LATS_DP_1VB.IADDR1_0.NCLK
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND
+  CAB[0] IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND
+  TCAB[0] IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND
+  TCAB[0] IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.ND
+  CAB[0] IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_0.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_0.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_1.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_1.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.I60.MXNA1 NCADDR_B[1]
+  IPH2LATS_DP_1VB.IADDR1_1.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.I60.MXPA1 NCADDR_B[1]
+  IPH2LATS_DP_1VB.IADDR1_1.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_1.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_1.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_1.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_1.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] IPH2LATS_DP_1VB.IADDR1_1.NCLK
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I62.MXNA1 CAYB[1]
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I62.MXPA1 CAYB[1]
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] IPH2LATS_DP_1VB.IADDR1_1.NCLK
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND
+  CAB[1] IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND
+  TCAB[1] IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND
+  TCAB[1] IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.ND
+  CAB[1] IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_1.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_1.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_10.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_10.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.I60.MXNA1 NRADDR_B[6]
+  IPH2LATS_DP_1VB.IADDR1_10.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.I60.MXPA1 NRADDR_B[6]
+  IPH2LATS_DP_1VB.IADDR1_10.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NDY
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NDY
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I50.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_10.Q_INT IPH2LATS_DP_1VB.NRADDR_INT_P2[6] VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I50.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_10.Q_INT IPH2LATS_DP_1VB.NRADDR_INT_P2[6] VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_10.Q_INT
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[6] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_10.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[6] IPH2LATS_DP_1VB.IADDR1_10.NCLK
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I62.MXNA1 RAYB[6]
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I62.MXPA1 RAYB[6]
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[6] IPH2LATS_DP_1VB.IADDR1_10.NCLK
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[6] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXN1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND RAB[6]
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXN2
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND TRAB[6]
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXN5
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXN6
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.N2 IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXP1
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND TRAB[6]
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXP3
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.ND RAB[6]
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXP4
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.P1 IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_10.Iaddrlat.MXP5
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_10.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_11.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_11.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.I60.MXNA1 NRADDR_B[7]
+  IPH2LATS_DP_1VB.IADDR1_11.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.I60.MXPA1 NRADDR_B[7]
+  IPH2LATS_DP_1VB.IADDR1_11.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NDY
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NDY
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I50.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_11.Q_INT IPH2LATS_DP_1VB.NRADDR_INT_P2[7] VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I50.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_11.Q_INT IPH2LATS_DP_1VB.NRADDR_INT_P2[7] VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_11.Q_INT
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[7] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_11.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[7] IPH2LATS_DP_1VB.IADDR1_11.NCLK
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I62.MXNA1 RAYB[7]
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I62.MXPA1 RAYB[7]
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[7] IPH2LATS_DP_1VB.IADDR1_11.NCLK
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[7] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXN1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND RAB[7]
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXN2
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND TRAB[7]
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXN5
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXN6
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.N2 IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXP1
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND TRAB[7]
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXP3
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.ND RAB[7]
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXP4
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.P1 IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_11.Iaddrlat.MXP5
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_11.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_12.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_12.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.I60.MXNA1 IPH2LATS_DP_1VB.NRADDR_P2[8]
+  IPH2LATS_DP_1VB.IADDR1_12.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.I60.MXPA1 IPH2LATS_DP_1VB.NRADDR_P2[8]
+  IPH2LATS_DP_1VB.IADDR1_12.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NDY
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NDY
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I50.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_12.Q_INT IPH2LATS_DP_1VB.NRADDR_INT_P2[8] VSS VPW
+  N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I50.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_12.Q_INT IPH2LATS_DP_1VB.NRADDR_INT_P2[8] VDDPE VNWP
+  P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_12.Q_INT
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[8] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_12.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[8] IPH2LATS_DP_1VB.IADDR1_12.NCLK
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I62.MXNA1 RAYB[8]
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I62.MXPA1 RAYB[8]
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[8] IPH2LATS_DP_1VB.IADDR1_12.NCLK
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[8] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXN1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND RAB[8]
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXN2
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND TRAB[8]
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXN5
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXN6
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.N2 IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXP1
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND TRAB[8]
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXP3
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.ND RAB[8]
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXP4
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.P1 IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_12.Iaddrlat.MXP5
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_12.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_2.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_2.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.I60.MXNA1 IPH2LATS_DP_1VB.NCADDR_P2[2]
+  IPH2LATS_DP_1VB.IADDR1_2.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.I60.MXPA1 IPH2LATS_DP_1VB.NCADDR_P2[2]
+  IPH2LATS_DP_1VB.IADDR1_2.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_2.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_2.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_2.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_2.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] IPH2LATS_DP_1VB.IADDR1_2.NCLK
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I62.MXNA1 CAYB[2]
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I62.MXPA1 CAYB[2]
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] IPH2LATS_DP_1VB.IADDR1_2.NCLK
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[2] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND
+  CAB[2] IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND
+  TCAB[2] IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND
+  TCAB[2] IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.ND
+  CAB[2] IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_2.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_2.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_3.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_3.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.I60.MXNA1 IPH2LATS_DP_1VB.NCADDR_P2[3]
+  IPH2LATS_DP_1VB.IADDR1_3.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.I60.MXPA1 IPH2LATS_DP_1VB.NCADDR_P2[3]
+  IPH2LATS_DP_1VB.IADDR1_3.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_3.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_3.Q_INT
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_3.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_3.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] IPH2LATS_DP_1VB.IADDR1_3.NCLK
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I62.MXNA1 CAYB[3]
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I62.MXPA1 CAYB[3]
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] IPH2LATS_DP_1VB.IADDR1_3.NCLK
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[3] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND
+  CAB[3] IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND
+  TCAB[3] IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND
+  TCAB[3] IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.ND
+  CAB[3] IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_3.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_3.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_4.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_4.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.I60.MXNA1 NRADDR_B[0]
+  IPH2LATS_DP_1VB.IADDR1_4.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.I60.MXPA1 NRADDR_B[0]
+  IPH2LATS_DP_1VB.IADDR1_4.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_4.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[0] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_4.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[0] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_4.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[0] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_4.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[0] IPH2LATS_DP_1VB.IADDR1_4.NCLK
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I62.MXNA1 RAYB[0]
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I62.MXPA1 RAYB[0]
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[0] IPH2LATS_DP_1VB.IADDR1_4.NCLK
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[0] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND
+  RAB[0] IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND
+  TRAB[0] IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND
+  TRAB[0] IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.ND
+  RAB[0] IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_4.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_4.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_5.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_5.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.I60.MXNA1 NRADDR_B[1]
+  IPH2LATS_DP_1VB.IADDR1_5.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.I60.MXPA1 NRADDR_B[1]
+  IPH2LATS_DP_1VB.IADDR1_5.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_5.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[1] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_5.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[1] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_5.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[1] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_5.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[1] IPH2LATS_DP_1VB.IADDR1_5.NCLK
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I62.MXNA1 RAYB[1]
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I62.MXPA1 RAYB[1]
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[1] IPH2LATS_DP_1VB.IADDR1_5.NCLK
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[1] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND
+  RAB[1] IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND
+  TRAB[1] IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND
+  TRAB[1] IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.ND
+  RAB[1] IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_5.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_5.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_6.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_6.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.I60.MXNA1 NRADDR_B[2]
+  IPH2LATS_DP_1VB.IADDR1_6.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.I60.MXPA1 NRADDR_B[2]
+  IPH2LATS_DP_1VB.IADDR1_6.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_6.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[2] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_6.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[2] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_6.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[2] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_6.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[2] IPH2LATS_DP_1VB.IADDR1_6.NCLK
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I62.MXNA1 RAYB[2]
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I62.MXPA1 RAYB[2]
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[2] IPH2LATS_DP_1VB.IADDR1_6.NCLK
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[2] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND
+  RAB[2] IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND
+  TRAB[2] IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND
+  TRAB[2] IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.ND
+  RAB[2] IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_6.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_6.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_7.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_7.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.I60.MXNA1 NRADDR_B[3]
+  IPH2LATS_DP_1VB.IADDR1_7.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.I60.MXPA1 NRADDR_B[3]
+  IPH2LATS_DP_1VB.IADDR1_7.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_7.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[3] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_7.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[3] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_7.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[3] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_7.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[3] IPH2LATS_DP_1VB.IADDR1_7.NCLK
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I62.MXNA1 RAYB[3]
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I62.MXPA1 RAYB[3]
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[3] IPH2LATS_DP_1VB.IADDR1_7.NCLK
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[3] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND
+  RAB[3] IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND
+  TRAB[3] IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND
+  TRAB[3] IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.ND
+  RAB[3] IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_7.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_7.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_8.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_8.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.I60.MXNA1 NRADDR_B[4]
+  IPH2LATS_DP_1VB.IADDR1_8.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.I60.MXPA1 NRADDR_B[4]
+  IPH2LATS_DP_1VB.IADDR1_8.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_8.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[4] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_8.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[4] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_8.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[4] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_8.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[4] IPH2LATS_DP_1VB.IADDR1_8.NCLK
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I62.MXNA1 RAYB[4]
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I62.MXPA1 RAYB[4]
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[4] IPH2LATS_DP_1VB.IADDR1_8.NCLK
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[4] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND
+  RAB[4] IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND
+  TRAB[4] IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND
+  TRAB[4] IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.ND
+  RAB[4] IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_8.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_8.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.I49.MXNA1 IPH2LATS_DP_1VB.IADDR1_9.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.I49.MXPA1 IPH2LATS_DP_1VB.IADDR1_9.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.2U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.I60.MXNA1 NRADDR_B[5]
+  IPH2LATS_DP_1VB.IADDR1_9.Q_INT VSS VPW N11LL_CKT W=3.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.I60.MXPA1 NRADDR_B[5]
+  IPH2LATS_DP_1VB.IADDR1_9.Q_INT VDDPE VNWP P11LL_CKT W=5.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I0.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.IDY
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I0.MXNA2
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.I0.N1 DFTRAMBYP_BUF_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I0.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NDY IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I0.MXPA2
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NDY DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I50.MXNA1 IPH2LATS_DP_1VB.IADDR1_9.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[5] VSS VPW N11LL_CKT W=0.96U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I50.MXPA1 IPH2LATS_DP_1VB.IADDR1_9.Q_INT
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[5] VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I55.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.I55.N1 IPH2LATS_DP_1VB.IADDR1_9.Q_INT VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I55.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[5] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I55.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.I55.P1 IPH2LATS_DP_1VB.IADDR1_9.Q_INT
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I55.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[5] IPH2LATS_DP_1VB.IADDR1_9.NCLK
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I57.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I57.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NSEL IPH2LATS_DP_1VB.TEN_I VDDPE VNWP
+  P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I62.MXNA1 RAYB[5]
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I62.MXPA1 RAYB[5]
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I63.MXNA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I63.MXPA1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.IDY IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I65.MXNOE
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[5] IPH2LATS_DP_1VB.IADDR1_9.NCLK
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND VPW N11LL_CKT W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.I65.MXPOEN
+  IPH2LATS_DP_1VB.NRADDR_INT_P2[5] IPH2LATS_DP_1VB.CLK_CTL
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND VNWP P11LL_CKT W=2.02U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXN1 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND
+  RAB[5] IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.N2 VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXN2 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND
+  TRAB[5] IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.N1 VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXN5 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.N1
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NSEL VSS VPW N11LL_CKT W=0.64U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXN6 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.28U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXP1 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND
+  TRAB[5] IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.P1 VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXP3 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.ND
+  RAB[5] IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.P2 VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXP4 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MIph2lats_dp_1vb.Iaddr1_9.Iaddrlat.MXP5 IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.P2
+  IPH2LATS_DP_1VB.IADDR1_9.IADDRLAT.NSEL VDDPE VNWP P11LL_CKT W=2.27U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_0.MXNA1 IPH2LATS_DP_1VB.CADDR_P2[0]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_0.MXPA1 IPH2LATS_DP_1VB.CADDR_P2[0]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[0] VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_1.MXNA1 IPH2LATS_DP_1VB.CADDR_P2[1]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_1.MXPA1 IPH2LATS_DP_1VB.CADDR_P2[1]
+  IPH2LATS_DP_1VB.NCADDR_INT_P2[1] VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_10.MXNA1 RADDR_B[8] IPH2LATS_DP_1VB.NRADDR_INT_P2[8]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_10.MXPA1 RADDR_B[8] IPH2LATS_DP_1VB.NRADDR_INT_P2[8]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_2.MXNA1 RADDR_B[0] IPH2LATS_DP_1VB.NRADDR_INT_P2[0]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_2.MXPA1 RADDR_B[0] IPH2LATS_DP_1VB.NRADDR_INT_P2[0]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_3.MXNA1 RADDR_B[1] IPH2LATS_DP_1VB.NRADDR_INT_P2[1]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_3.MXPA1 RADDR_B[1] IPH2LATS_DP_1VB.NRADDR_INT_P2[1]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_4.MXNA1 RADDR_B[2] IPH2LATS_DP_1VB.NRADDR_INT_P2[2]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_4.MXPA1 RADDR_B[2] IPH2LATS_DP_1VB.NRADDR_INT_P2[2]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_5.MXNA1 RADDR_B[3] IPH2LATS_DP_1VB.NRADDR_INT_P2[3]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_5.MXPA1 RADDR_B[3] IPH2LATS_DP_1VB.NRADDR_INT_P2[3]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_6.MXNA1 RADDR_B[4] IPH2LATS_DP_1VB.NRADDR_INT_P2[4]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_6.MXPA1 RADDR_B[4] IPH2LATS_DP_1VB.NRADDR_INT_P2[4]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_7.MXNA1 RADDR_B[5] IPH2LATS_DP_1VB.NRADDR_INT_P2[5]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_7.MXPA1 RADDR_B[5] IPH2LATS_DP_1VB.NRADDR_INT_P2[5]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_8.MXNA1 RADDR_B[6] IPH2LATS_DP_1VB.NRADDR_INT_P2[6]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_8.MXPA1 RADDR_B[6] IPH2LATS_DP_1VB.NRADDR_INT_P2[6]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_9.MXNA1 RADDR_B[7] IPH2LATS_DP_1VB.NRADDR_INT_P2[7]
+  VSS VPW N11LL_CKT W=2.95U L=0.04U
X_MIph2lats_dp_1vb.Iaddrq_9.MXPA1 RADDR_B[7] IPH2LATS_DP_1VB.NRADDR_INT_P2[7]
+  VDDPE VNWP P11LL_CKT W=4.55U L=0.04U
X_MIph2lats_dp_1vb.Icaddrq_0.MXNA1 CADDR_B[2] IPH2LATS_DP_1VB.NET271[1] VSS
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIph2lats_dp_1vb.Icaddrq_0.MXPA1 CADDR_B[2] IPH2LATS_DP_1VB.NET271[1] VDDPE
+  VNWP P11LL_CKT W=1.1U L=0.04U
X_MIph2lats_dp_1vb.Icaddrq_1.MXNA1 CADDR_B[3] IPH2LATS_DP_1VB.NET271[0] VSS
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIph2lats_dp_1vb.Icaddrq_1.MXPA1 CADDR_B[3] IPH2LATS_DP_1VB.NET271[0] VDDPE
+  VNWP P11LL_CKT W=1.1U L=0.04U
X_MIph2lats_dp_1vb.Icen.I49.MXNA1 IPH2LATS_DP_1VB.ICEN.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Icen.I49.MXPA1 IPH2LATS_DP_1VB.ICEN.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I0.MXNA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.IDY IPH2LATS_DP_1VB.ICEN.ICTLLAT.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I0.MXNA2 IPH2LATS_DP_1VB.ICEN.ICTLLAT.I0.N1
+  DFTRAMBYP_BUF_B VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I0.MXPA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I0.MXPA2 IPH2LATS_DP_1VB.ICEN.ICTLLAT.NDY
+  DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I50.MXNA1 NCE_B IPH2LATS_DP_1VB.ICEN.NQ_INT
+  VSS VPW N11LL_CKT W=2U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I50.MXPA1 NCE_B IPH2LATS_DP_1VB.ICEN.NQ_INT
+  VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I55.MXNA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.I55.N1
+  NCE_B VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I55.MXNOE IPH2LATS_DP_1VB.ICEN.NQ_INT
+  IPH2LATS_DP_1VB.CLK_CTL IPH2LATS_DP_1VB.ICEN.ICTLLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I55.MXPA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.I55.P1
+  NCE_B VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I55.MXPOEN IPH2LATS_DP_1VB.ICEN.NQ_INT
+  IPH2LATS_DP_1VB.ICEN.NCLK IPH2LATS_DP_1VB.ICEN.ICTLLAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I57.MXNA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I57.MXPA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I62.MXNA1 CENYB
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I62.MXPA1 CENYB
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I63.MXNA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I63.MXPA1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I65.MXNOE IPH2LATS_DP_1VB.ICEN.NQ_INT
+  IPH2LATS_DP_1VB.ICEN.NCLK IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND VPW N11LL_CKT
+  W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.I65.MXPOEN IPH2LATS_DP_1VB.ICEN.NQ_INT
+  IPH2LATS_DP_1VB.CLK_CTL IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND VNWP P11LL_CKT
+  W=1.8U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXN1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND CENB
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.N2 VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXN2 IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND TCENB
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.N1 VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXN5 IPH2LATS_DP_1VB.ICEN.ICTLLAT.N1
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.NSEL VSS VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXN6 IPH2LATS_DP_1VB.ICEN.ICTLLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXP1 IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND TCENB
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.P1 VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXP3 IPH2LATS_DP_1VB.ICEN.ICTLLAT.ND CENB
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.P2 VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXP4 IPH2LATS_DP_1VB.ICEN.ICTLLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1vb.Icen.Ictllat.MXP5 IPH2LATS_DP_1VB.ICEN.ICTLLAT.P2
+  IPH2LATS_DP_1VB.ICEN.ICTLLAT.NSEL VDDPE VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1vb.Idft.I49.MXNA1 IPH2LATS_DP_1VB.IDFT.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Idft.I49.MXPA1 IPH2LATS_DP_1VB.IDFT.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I47.MXNA1 IPH2LATS_DP_1VB.IDFT.IDFTLAT.ND
+  DFTRAMBYP VSS VPW N11LL_CKT W=0.57U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I47.MXPA1 IPH2LATS_DP_1VB.IDFT.IDFTLAT.ND
+  DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.85U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I48.MXNOE IPH2LATS_DP_1VB.IDFT.NQ_INT
+  IPH2LATS_DP_1VB.IDFT.NCLK IPH2LATS_DP_1VB.IDFT.IDFTLAT.ND VPW N11LL_CKT
+  W=0.57U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I48.MXPOEN IPH2LATS_DP_1VB.IDFT.NQ_INT
+  IPH2LATS_DP_1VB.CLK_CTL IPH2LATS_DP_1VB.IDFT.IDFTLAT.ND VNWP P11LL_CKT
+  W=0.57U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I50.MXNA1 DFTRAMBYP_P2_B
+  IPH2LATS_DP_1VB.IDFT.NQ_INT VSS VPW N11LL_CKT W=1.42U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I50.MXPA1 DFTRAMBYP_P2_B
+  IPH2LATS_DP_1VB.IDFT.NQ_INT VDDPE VNWP P11LL_CKT W=1.99U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I55.MXNA1 IPH2LATS_DP_1VB.IDFT.IDFTLAT.I55.N1
+  DFTRAMBYP_P2_B VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I55.MXNOE IPH2LATS_DP_1VB.IDFT.NQ_INT
+  IPH2LATS_DP_1VB.CLK_CTL IPH2LATS_DP_1VB.IDFT.IDFTLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I55.MXPA1 IPH2LATS_DP_1VB.IDFT.IDFTLAT.I55.P1
+  DFTRAMBYP_P2_B VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Idft.Idftlat.I55.MXPOEN IPH2LATS_DP_1VB.IDFT.NQ_INT
+  IPH2LATS_DP_1VB.IDFT.NCLK IPH2LATS_DP_1VB.IDFT.IDFTLAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Igwen.I49.MXNA1 IPH2LATS_DP_1VB.IGWEN.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Igwen.I49.MXPA1 IPH2LATS_DP_1VB.IGWEN.NCLK
+  IPH2LATS_DP_1VB.CLK_CTL VDDPE VNWP P11LL_CKT W=0.205U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I0.MXNA1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.IDY IPH2LATS_DP_1VB.IGWEN.ICTLLAT.I0.N1 VPW
+  N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I0.MXNA2 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.I0.N1
+  DFTRAMBYP_BUF_B VSS VPW N11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I0.MXPA1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NDY
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.IDY VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I0.MXPA2 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NDY
+  DFTRAMBYP_BUF_B VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I50.MXNA1 NGWE_B IPH2LATS_DP_1VB.IGWEN.NQ_INT
+  VSS VPW N11LL_CKT W=2U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I50.MXPA1 NGWE_B IPH2LATS_DP_1VB.IGWEN.NQ_INT
+  VDDPE VNWP P11LL_CKT W=3.12U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I55.MXNA1
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.I55.N1 NGWE_B VSS VPW N11LL_CKT W=0.15U
+  L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I55.MXNOE IPH2LATS_DP_1VB.IGWEN.NQ_INT
+  IPH2LATS_DP_1VB.CLK_CTL IPH2LATS_DP_1VB.IGWEN.ICTLLAT.I55.N1 VPW N11LL_CKT
+  W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I55.MXPA1
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.I55.P1 NGWE_B VDDPE VNWP P11LL_CKT W=0.15U
+  L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I55.MXPOEN IPH2LATS_DP_1VB.IGWEN.NQ_INT
+  IPH2LATS_DP_1VB.IGWEN.NCLK IPH2LATS_DP_1VB.IGWEN.ICTLLAT.I55.P1 VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I57.MXNA1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I57.MXPA1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NSEL
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I62.MXNA1 GWENYB
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NDY VSS VPW N11LL_CKT W=0.5U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I62.MXPA1 GWENYB
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NDY VDDPE VNWP P11LL_CKT W=1.12U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I63.MXNA1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I63.MXPA1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.IDY
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I65.MXNOE IPH2LATS_DP_1VB.IGWEN.NQ_INT
+  IPH2LATS_DP_1VB.IGWEN.NCLK IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND VPW N11LL_CKT
+  W=1.34U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.I65.MXPOEN IPH2LATS_DP_1VB.IGWEN.NQ_INT
+  IPH2LATS_DP_1VB.CLK_CTL IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND VNWP P11LL_CKT
+  W=1.8U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXN1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND GWENB
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.N2 VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXN2 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND TGWENB
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.N1 VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXN5 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.N1
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NSEL VSS VPW N11LL_CKT W=0.58U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXN6 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.N2
+  IPH2LATS_DP_1VB.TEN_I VSS VPW N11LL_CKT W=1.16U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXP1 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND TGWENB
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.P1 VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXP3 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.ND GWENB
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.P2 VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXP4 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.P1
+  IPH2LATS_DP_1VB.TEN_I VDDPE VNWP P11LL_CKT W=1.09U L=0.04U
X_MIph2lats_dp_1vb.Igwen.Ictllat.MXP5 IPH2LATS_DP_1VB.IGWEN.ICTLLAT.P2
+  IPH2LATS_DP_1VB.IGWEN.ICTLLAT.NSEL VDDPE VNWP P11LL_CKT W=2.18U L=0.04U
X_MIph2lats_dp_1vb.Ilogicgen.Ilogicgen.MXN0 IPH2LATS_DP_1VB.ZERO
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEB VSS VPW N11LL_CKT W=0.51U L=0.04U
X_MIph2lats_dp_1vb.Ilogicgen.Ilogicgen.MXN1
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEA
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEA VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIph2lats_dp_1vb.Ilogicgen.Ilogicgen.MXN2
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEA
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEB VSS VPW N11LL_CKT W=0.3U L=0.04U
X_MIph2lats_dp_1vb.Ilogicgen.Ilogicgen.MXP1
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEB
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=0.39U
+  L=0.04U
X_MIph2lats_dp_1vb.Ilogicgen.Ilogicgen.MXP4 IPH2LATS_DP_1VB.ONE
+  IPH2LATS_DP_1VB.ILOGICGEN.ILOGICGEN.NODEA VDDPE VNWP P11LL_CKT W=1U L=0.04U
X_MIph2lats_dp_1vb.MXN_try LOG0 IPH2LATS_DP_1VB.ONE VSS VPW N11LL_CKT W=3.84U
+  L=0.04U
X_MIph2lats_dp_1vb.MXP0 LOG1 IPH2LATS_DP_1VB.ZERO VDDPE VNWP P11LL_CKT W=1.92U
+  L=0.04U
X_MIscanlogica.I2.MXNA1 SEL_SI_A ISCANLOGICA.NSE VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIscanlogica.I2.MXPA1 SEL_SI_A ISCANLOGICA.NSE VDDPE VNWP P11LL_CKT W=2.85U
+  L=0.04U
X_MIscanlogica.I4.MXNA1 SEL_TD_A ISCANLOGICA.NET18 VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIscanlogica.I4.MXPA1 SEL_TD_A ISCANLOGICA.NET18 VDDPE VNWP P11LL_CKT
+  W=2.85U L=0.04U
X_MIscanlogica.I5.MXNA1 SEL_D_A ISCANLOGICA.TE VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIscanlogica.I5.MXPA1 SEL_D_A ISCANLOGICA.TE VDDPE VNWP P11LL_CKT W=2.85U
+  L=0.04U
X_MIscanlogica.I7.MXNA1 ISCANLOGICA.NSE SEA VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscanlogica.I7.MXPA1 ISCANLOGICA.NSE SEA VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscanlogica.I8.MXNA1 ISCANLOGICA.NET18 ISCANLOGICA.NSE ISCANLOGICA.I8.N1
+  VPW N11LL_CKT W=0.425U L=0.04U
X_MIscanlogica.I8.MXNA2 ISCANLOGICA.I8.N1 ISCANLOGICA.TE VSS VPW N11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogica.I8.MXPA1 ISCANLOGICA.NET18 ISCANLOGICA.NSE VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogica.I8.MXPA2 ISCANLOGICA.NET18 ISCANLOGICA.TE VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogica.I83.MXNA1 ISCANLOGICA.TE ISCANLOGICA.NSE ISCANLOGICA.I83.N1 VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIscanlogica.I83.MXNA2 ISCANLOGICA.I83.N1 TENA VSS VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MIscanlogica.I83.MXPA1 ISCANLOGICA.TE ISCANLOGICA.NSE VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogica.I83.MXPA2 ISCANLOGICA.TE TENA VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_MIscanlogicb.I2.MXNA1 SEL_SI_B ISCANLOGICB.NSE VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIscanlogicb.I2.MXPA1 SEL_SI_B ISCANLOGICB.NSE VDDPE VNWP P11LL_CKT W=2.85U
+  L=0.04U
X_MIscanlogicb.I4.MXNA1 SEL_TD_B ISCANLOGICB.NET18 VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIscanlogicb.I4.MXPA1 SEL_TD_B ISCANLOGICB.NET18 VDDPE VNWP P11LL_CKT
+  W=2.85U L=0.04U
X_MIscanlogicb.I5.MXNA1 SEL_D_B ISCANLOGICB.TE VSS VPW N11LL_CKT W=1.42U
+  L=0.04U
X_MIscanlogicb.I5.MXPA1 SEL_D_B ISCANLOGICB.TE VDDPE VNWP P11LL_CKT W=2.85U
+  L=0.04U
X_MIscanlogicb.I7.MXNA1 ISCANLOGICB.NSE SEB VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscanlogicb.I7.MXPA1 ISCANLOGICB.NSE SEB VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscanlogicb.I8.MXNA1 ISCANLOGICB.NET18 ISCANLOGICB.NSE ISCANLOGICB.I8.N1
+  VPW N11LL_CKT W=0.425U L=0.04U
X_MIscanlogicb.I8.MXNA2 ISCANLOGICB.I8.N1 ISCANLOGICB.TE VSS VPW N11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogicb.I8.MXPA1 ISCANLOGICB.NET18 ISCANLOGICB.NSE VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogicb.I8.MXPA2 ISCANLOGICB.NET18 ISCANLOGICB.TE VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogicb.I83.MXNA1 ISCANLOGICB.TE ISCANLOGICB.NSE ISCANLOGICB.I83.N1 VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIscanlogicb.I83.MXNA2 ISCANLOGICB.I83.N1 TENB VSS VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MIscanlogicb.I83.MXPA1 ISCANLOGICB.TE ISCANLOGICB.NSE VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIscanlogicb.I83.MXPA2 ISCANLOGICB.TE TENB VDDPE VNWP P11LL_CKT W=0.425U
+  L=0.04U
X_MIscbuf_0.I48.MXNA1 ISCBUF_0.NET28 PENSOB VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscbuf_0.I48.MXPA1 ISCBUF_0.NET28 PENSOB VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_0.I49.MXNA1 BPENSOB ISCBUF_0.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_0.I49.MXPA1 BPENSOB ISCBUF_0.NET28 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MIscbuf_1.I48.MXNA1 ISCBUF_1.NET28 PENSOA VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscbuf_1.I48.MXPA1 ISCBUF_1.NET28 PENSOA VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_1.I49.MXNA1 BPENSOA ISCBUF_1.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_1.I49.MXPA1 BPENSOA ISCBUF_1.NET28 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MIscbuf_2.I48.MXNA1 ISCBUF_2.NET28 PSOB[0] VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MIscbuf_2.I48.MXPA1 ISCBUF_2.NET28 PSOB[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_2.I49.MXNA1 BPSOB[0] ISCBUF_2.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_2.I49.MXPA1 BPSOB[0] ISCBUF_2.NET28 VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIscbuf_3.I48.MXNA1 ISCBUF_3.NET28 PSOB[1] VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MIscbuf_3.I48.MXPA1 ISCBUF_3.NET28 PSOB[1] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_3.I49.MXNA1 BPSOB[1] ISCBUF_3.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_3.I49.MXPA1 BPSOB[1] ISCBUF_3.NET28 VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIscbuf_4.I48.MXNA1 ISCBUF_4.NET28 PSOA[0] VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MIscbuf_4.I48.MXPA1 ISCBUF_4.NET28 PSOA[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_4.I49.MXNA1 BPSOA[0] ISCBUF_4.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_4.I49.MXPA1 BPSOA[0] ISCBUF_4.NET28 VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIscbuf_5.I48.MXNA1 ISCBUF_5.NET28 PSOA[1] VSS VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MIscbuf_5.I48.MXPA1 ISCBUF_5.NET28 PSOA[1] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_5.I49.MXNA1 BPSOA[1] ISCBUF_5.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_5.I49.MXPA1 BPSOA[1] ISCBUF_5.NET28 VDDPE VNWP P11LL_CKT W=2U
+  L=0.04U
X_MIscbuf_6.I48.MXNA1 ISCBUF_6.NET28 SOB[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscbuf_6.I48.MXPA1 ISCBUF_6.NET28 SOB[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_6.I49.MXNA1 BSOB[0] ISCBUF_6.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_6.I49.MXPA1 BSOB[0] ISCBUF_6.NET28 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MIscbuf_7.I48.MXNA1 ISCBUF_7.NET28 SOB[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscbuf_7.I48.MXPA1 ISCBUF_7.NET28 SOB[1] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_7.I49.MXNA1 BSOB[1] ISCBUF_7.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_7.I49.MXPA1 BSOB[1] ISCBUF_7.NET28 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MIscbuf_8.I48.MXNA1 ISCBUF_8.NET28 SOA[0] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscbuf_8.I48.MXPA1 ISCBUF_8.NET28 SOA[0] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_8.I49.MXNA1 BSOA[0] ISCBUF_8.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_8.I49.MXPA1 BSOA[0] ISCBUF_8.NET28 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MIscbuf_9.I48.MXNA1 ISCBUF_9.NET28 SOA[1] VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIscbuf_9.I48.MXPA1 ISCBUF_9.NET28 SOA[1] VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIscbuf_9.I49.MXNA1 BSOA[1] ISCBUF_9.NET28 VSS VPW N11LL_CKT W=1U L=0.04U
X_MIscbuf_9.I49.MXPA1 BSOA[1] ISCBUF_9.NET28 VDDPE VNWP P11LL_CKT W=2U L=0.04U
X_MXN0 LOG0_PG LOGIC1 VSS VPW N11LL_CKT W=8.94U L=0.04U
X_MXN3 LOG0_DBL LOGIC1 VSS VPW N11LL_CKT W=14.61U L=0.04U
.ENDS SRAMdpw64d256CNTL_1V
****
.SUBCKT SRAMdpw64d256CNTL1VR64M4 ACTCLMP ACTCLMP_A ACTCLMP_B ACT_CTLM
+  BDFTRAMBYP_A BDFTRAMBYP_B BPENSOA BPENSOB BPSOA[0] BPSOA[1] BPSOB[0]
+  BPSOB[1] BSEL_D_A BSEL_D_B BSEL_SI_A BSEL_SI_B BSEL_TD_A BSEL_TD_B BSOA[0]
+  BSOA[1] BSOB[0] BSOB[1] CAA[0] CAA[1] CAA[2] CAB[0] CAB[1] CADDR_A[2]
+  CADDR_A[3] CADDR_B[2] CADDR_B[3] CAYA[0] CAYA[1] CAYA[2] CAYA[3] CAYB[0]
+  CAYB[1] CAYB[2] CAYB[3] CENA CENB CENYA CENYB CLKA CLKB COLLDISN DA[0]
+  DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12]
+  DA[13] DA[14] DA[15] DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DA_8 DA_9
+  DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16 DA_17 DA_18 DA_19 DA_20 DA_21
+  DA_22 DA_23 DA_24 DA_25 DA_26 DA_27 DA_28 DA_29 DA_30 DA_31 DA_32 DA_33
+  DA_34 DA_35 DA_36 DA_37 DA_38 DA_39 DA_40 DA_41 DA_42 DA_43 DA_44 DA_45
+  DA_46 DA_47 DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9]
+  DB[10] DB[11] DB[12] DB[13] DB[14] DB[15] DB_0 DB_1 DB_2 DB_3 DB_4 DB_5
+  DB_6 DB_7 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18
+  DB_19 DB_20 DB_21 DB_22 DB_23 DB_24 DB_25 DB_26 DB_27 DB_28 DB_29 DB_30
+  DB_31 DB_32 DB_33 DB_34 DB_35 DB_36 DB_37 DB_38 DB_39 DB_40 DB_41 DB_42
+  DB_43 DB_44 DB_45 DB_46 DB_47 DFTRAMBYP DFTRAMBYP_BUF_A DFTRAMBYP_BUF_B
+  EMAA[0] EMAA[1] EMAA[2] EMAA_DEP2[0] EMAA_DEP2[1] EMAA_DEP2[2] EMAB[0]
+  EMAB[1] EMAB[2] EMAB_DEP2[0] EMAB_DEP2[1] EMAB_DEP2[2] EMAWA[0] EMAWA[1]
+  EMAWA_DEP2[0] EMAWA_DEP2[1] EMAWB[0] EMAWB[1] EMAWB_DEP2[0] EMAWB_DEP2[1]
+  GWENA GWENB GWENYA GWENYB LOG0_DBL LOG0_PG NBNK_A NBNK_B NCADDR_A[0]
+  NCADDR_A[1] NCADDR_B[0] NCADDR_B[1] NCE_A NCE_B NCLK_CTL_A NCLK_CTL_B
+  NC_PGEN NC_RET2N NDFTCRE1 NDFTCRE2 NGWE_A NGWE_B NGWE_WT_A NGWE_WT_B
+  NHDR_WL_A NHDR_WL_B NRDTA NRDTB NRETNVT NRET_A NRET_ACT_FT1_A
+  NRET_ACT_FT2_A NRET_B NTE_A NTE_B NWRA_MA NWRB_MA NWTE_A NWTE_B
+  NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] PENSOA
+  PENSOB PSIA_0 PSIA_1 PSIB_0 PSIB_1 PSOA[0] PSOA[1] PSOB[0] PSOB[1] QA[0]
+  QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11] QA[12]
+  QA[13] QA[14] QA[15] QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA_8 QA_9
+  QA_10 QA_11 QA_12 QA_13 QA_14 QA_15 QA_16 QA_17 QA_18 QA_19 QA_20 QA_21
+  QA_22 QA_23 QA_24 QA_25 QA_26 QA_27 QA_28 QA_29 QA_30 QA_31 QA_32 QA_33
+  QA_34 QA_35 QA_36 QA_37 QA_38 QA_39 QA_40 QA_41 QA_42 QA_43 QA_44 QA_45
+  QA_46 QA_47 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+  QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB_0 QB_1 QB_2 QB_3 QB_4 QB_5
+  QB_6 QB_7 QB_8 QB_9 QB_10 QB_11 QB_12 QB_13 QB_14 QB_15 QB_16 QB_17 QB_18
+  QB_19 QB_20 QB_21 QB_22 QB_23 QB_24 QB_25 QB_26 QB_27 QB_28 QB_29 QB_30
+  QB_31 QB_32 QB_33 QB_34 QB_35 QB_36 QB_37 QB_38 QB_39 QB_40 QB_41 QB_42
+  QB_43 QB_44 QB_45 QB_46 QB_47 RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5]
+  RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RAYA[0] RAYA[1] RAYA[2] RAYA[3]
+  RAYA[4] RAYA[5] RAYA[6] RAYA[7] RAYA[8] RAYB[0] RAYB[1] RAYB[2] RAYB[3]
+  RAYB[4] RAYB[5] RAYB[6] RAYB[7] RAYB[8] RET1N RET_A RET_B SEA SEB SIA_0
+  SIA_1 SIB_0 SIB_1 SOA[0] SOA[1] SOB[0] SOB[1] TCAA[0] TCAA[1] TCAB[0]
+  TCAB[1] TCENA TCENB TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5] TDA[6] TDA[7]
+  TDA[8] TDA[9] TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15] TDA_0 TDA_1
+  TDA_2 TDA_3 TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13
+  TDA_14 TDA_15 TDA_16 TDA_17 TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23
+  TDA_24 TDA_25 TDA_26 TDA_27 TDA_28 TDA_29 TDA_30 TDA_31 TDA_32 TDA_33
+  TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43
+  TDA_44 TDA_45 TDA_46 TDA_47 TDB[0] TDB[1] TDB[2] TDB[3] TDB[4] TDB[5]
+  TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12] TDB[13] TDB[14] TDB[15]
+  TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7 TDB_8 TDB_9 TDB_10 TDB_11
+  TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18 TDB_19 TDB_20 TDB_21
+  TDB_22 TDB_23 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28 TDB_29 TDB_30 TDB_31
+  TDB_32 TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38 TDB_39 TDB_40 TDB_41
+  TDB_42 TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TENA TENB TGWENA TGWENB TRAA[0]
+  TRAA[1] TRAA[2] TRAA[3] TRAA[4] TRAA[5] TRAB[0] TRAB[1] TRAB[2] TRAB[3]
+  TRAB[4] TRAB[5] TWENA[0] TWENA[1] TWENA[2] TWENA[3] TWENA[4] TWENA[5]
+  TWENA[6] TWENA[7] TWENA[8] TWENA[9] TWENA[10] TWENA[11] TWENA[12] TWENA[13]
+  TWENA[14] TWENA[15] TWENA_0 TWENA_1 TWENA_2 TWENA_3 TWENA_4 TWENA_5 TWENA_6
+  TWENA_7 TWENA_8 TWENA_9 TWENA_10 TWENA_11 TWENA_12 TWENA_13 TWENA_14
+  TWENA_15 TWENA_16 TWENA_17 TWENA_18 TWENA_19 TWENA_20 TWENA_21 TWENA_22
+  TWENA_23 TWENA_24 TWENA_25 TWENA_26 TWENA_27 TWENA_28 TWENA_29 TWENA_30
+  TWENA_31 TWENA_32 TWENA_33 TWENA_34 TWENA_35 TWENA_36 TWENA_37 TWENA_38
+  TWENA_39 TWENA_40 TWENA_41 TWENA_42 TWENA_43 TWENA_44 TWENA_45 TWENA_46
+  TWENA_47 TWENB[0] TWENB[1] TWENB[2] TWENB[3] TWENB[4] TWENB[5] TWENB[6]
+  TWENB[7] TWENB[8] TWENB[9] TWENB[10] TWENB[11] TWENB[12] TWENB[13]
+  TWENB[14] TWENB[15] TWENB_0 TWENB_1 TWENB_2 TWENB_3 TWENB_4 TWENB_5 TWENB_6
+  TWENB_7 TWENB_8 TWENB_9 TWENB_10 TWENB_11 TWENB_12 TWENB_13 TWENB_14
+  TWENB_15 TWENB_16 TWENB_17 TWENB_18 TWENB_19 TWENB_20 TWENB_21 TWENB_22
+  TWENB_23 TWENB_24 TWENB_25 TWENB_26 TWENB_27 TWENB_28 TWENB_29 TWENB_30
+  TWENB_31 TWENB_32 TWENB_33 TWENB_34 TWENB_35 TWENB_36 TWENB_37 TWENB_38
+  TWENB_39 TWENB_40 TWENB_41 TWENB_42 TWENB_43 TWENB_44 TWENB_45 TWENB_46
+  TWENB_47 VNWC VNWP VPW WENA[0] WENA[1] WENA[2] WENA[3] WENA[4] WENA[5]
+  WENA[6] WENA[7] WENA[8] WENA[9] WENA[10] WENA[11] WENA[12] WENA[13]
+  WENA[14] WENA[15] WENA_0 WENA_1 WENA_2 WENA_3 WENA_4 WENA_5 WENA_6 WENA_7
+  WENA_8 WENA_9 WENA_10 WENA_11 WENA_12 WENA_13 WENA_14 WENA_15 WENA_16
+  WENA_17 WENA_18 WENA_19 WENA_20 WENA_21 WENA_22 WENA_23 WENA_24 WENA_25
+  WENA_26 WENA_27 WENA_28 WENA_29 WENA_30 WENA_31 WENA_32 WENA_33 WENA_34
+  WENA_35 WENA_36 WENA_37 WENA_38 WENA_39 WENA_40 WENA_41 WENA_42 WENA_43
+  WENA_44 WENA_45 WENA_46 WENA_47 WENB[0] WENB[1] WENB[2] WENB[3] WENB[4]
+  WENB[5] WENB[6] WENB[7] WENB[8] WENB[9] WENB[10] WENB[11] WENB[12] WENB[13]
+  WENB[14] WENB[15] WENB_0 WENB_1 WENB_2 WENB_3 WENB_4 WENB_5 WENB_6 WENB_7
+  WENB_8 WENB_9 WENB_10 WENB_11 WENB_12 WENB_13 WENB_14 WENB_15 WENB_16
+  WENB_17 WENB_18 WENB_19 WENB_20 WENB_21 WENB_22 WENB_23 WENB_24 WENB_25
+  WENB_26 WENB_27 WENB_28 WENB_29 WENB_30 WENB_31 WENB_32 WENB_33 WENB_34
+  WENB_35 WENB_36 WENB_37 WENB_38 WENB_39 WENB_40 WENB_41 WENB_42 WENB_43
+  WENB_44 WENB_45 WENB_46 WENB_47 WENYA[0] WENYA[1] WENYA[2] WENYA[3]
+  WENYA[4] WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11]
+  WENYA[12] WENYA[13] WENYA[14] WENYA[15] WENYA_0 WENYA_1 WENYA_2 WENYA_3
+  WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9 WENYA_10 WENYA_11 WENYA_12
+  WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17 WENYA_18 WENYA_19 WENYA_20
+  WENYA_21 WENYA_22 WENYA_23 WENYA_24 WENYA_25 WENYA_26 WENYA_27 WENYA_28
+  WENYA_29 WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35 WENYA_36
+  WENYA_37 WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43 WENYA_44
+  WENYA_45 WENYA_46 WENYA_47 WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4]
+  WENYB[5] WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12]
+  WENYB[13] WENYB[14] WENYB[15] WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4
+  WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13
+  WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21
+  WENYB_22 WENYB_23 WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29
+  WENYB_30 WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37
+  WENYB_38 WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45
+  WENYB_46 WENYB_47
** SRAMdpw64d256CNTL1VR64M4: 1921 flat devices **
XCTRL ACTCLMP ACTCLMP_A ACTCLMP_B ACT_CTLM BDFTRAMBYP_A BDFTRAMBYP_B BPENSOA
+  BPENSOB BPSOA[0] BPSOA[1] BPSOB[0] BPSOB[1] BSEL_D_A BSEL_D_B BSEL_SI_A
+  BSEL_SI_B BSEL_TD_A BSEL_TD_B BSOA[0] BSOA[1] BSOB[0] BSOB[1] CAA[0] CAA[1]
+  CAA[2] CAA[2] CAB[0] CAB[1] CAA[2] CAA[2] CADDR_A[2] CADDR_A[3] CADDR_B[2]
+  CADDR_B[3] CAYA[0] CAYA[1] CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2] CAYB[3]
+  CENA CENB CENYA CENYB CLKA CLKB COLLDISN CRE1 CRE2 DA[0] DA[1] DA[2] DA[3]
+  DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14]
+  DA[15] DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10]
+  DB[11] DB[12] DB[13] DB[14] DB[15] DFTRAMBYP DFTRAMBYP_BUF_A
+  DFTRAMBYP_BUF_B EMAA[0] EMAA[1] EMAA[2] EMAA_DEP2[0] EMAA_DEP2[1]
+  EMAA_DEP2[2] EMAB[0] EMAB[1] EMAB[2] EMAB_DEP2[0] EMAB_DEP2[1] EMAB_DEP2[2]
+  EMAWA[0] EMAWA[1] EMAWA_DEP2[0] EMAWA_DEP2[1] EMAWB[0] EMAWB[1]
+  EMAWB_DEP2[0] EMAWB_DEP2[1] GWENA GWENB GWENYA GWENYB CAA[2] CRE1 CRE2
+  LOG0_DBL LOG0_PG ACTCLMP ACT_CTLM NBNK_A NBNK_B NCADDR_A[0] NCADDR_A[1]
+  NCADDR_B[0] NCADDR_B[1] NCE_A NCE_B NCLK_CTL_A NCLK_CTL_B NC_PGEN NC_RET2N
+  NDFTCRE1 NDFTCRE2 ACT_CTLM NGWE_A NGWE_B NGWE_WT_A NGWE_WT_B NHDR_WL_A
+  NHDR_WL_B NIRET NRDTA NRDTB NRETNVT NRET_A NRET_ACT_FT1_A NRET_ACT_FT2_A
+  NRET_B NTE_A NTE_B NWRA_MA NWRB_MA NWTE_A NWTE_B NXPDEC1_A[0] NXPDEC1_A[1]
+  NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4] NXPDEC1_A[5] NXPDEC1_A[6]
+  NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1] NXPDEC1_B[2] NXPDEC1_B[3]
+  NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6] NXPDEC1_B[7] NXPDEC2_A[0]
+  NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3] NXPDEC2_A[4] NXPDEC2_A[5]
+  NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0] NXPDEC2_B[1] NXPDEC2_B[2]
+  NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5] NXPDEC2_B[6] NXPDEC2_B[7]
+  NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2] NXPDEC3_A[3] NXPDEC3_B[0]
+  NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] NRETNVT VPW VPW VPW VPW PENSOA
+  PENSOB ACT_CTLM PSOA[0] PSOA[1] PSOB[0] PSOB[1] QA[0] QA[1] QA[2] QA[3]
+  QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14]
+  QA[15] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10]
+  QB[11] QB[12] QB[13] QB[14] QB[15] RAA[0] RAA[1] RAA[2] RAA[3] RAA[4]
+  RAA[5] CAA[2] CAA[2] CAA[2] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5]
+  CAA[2] CAA[2] CAA[2] RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4] RAYA[5]
+  RAYA[6] RAYA[7] RAYA[8] RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4] RAYB[5]
+  RAYB[6] RAYB[7] RAYB[8] CAA[2] CAA[2] RET1N NIRET RET_A RET_B SEA SEB
+  SOA[0] SOA[1] SOB[0] SOB[1] TCAA[0] TCAA[1] CAA[2] CAA[2] TCAB[0] TCAB[1]
+  CAA[2] CAA[2] TCENA TCENB TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5] TDA[6]
+  TDA[7] TDA[8] TDA[9] TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15] TDB[0]
+  TDB[1] TDB[2] TDB[3] TDB[4] TDB[5] TDB[6] TDB[7] TDB[8] TDB[9] TDB[10]
+  TDB[11] TDB[12] TDB[13] TDB[14] TDB[15] TENA TENB TGWENA TGWENB VPW VPW
+  TRAA[0] TRAA[1] TRAA[2] TRAA[3] TRAA[4] TRAA[5] CAA[2] CAA[2] CAA[2]
+  TRAB[0] TRAB[1] TRAB[2] TRAB[3] TRAB[4] TRAB[5] CAA[2] CAA[2] CAA[2]
+  TWENA[0] TWENA[1] TWENA[2] TWENA[3] TWENA[4] TWENA[5] TWENA[6] TWENA[7]
+  TWENA[8] TWENA[9] TWENA[10] TWENA[11] TWENA[12] TWENA[13] TWENA[14]
+  TWENA[15] TWENB[0] TWENB[1] TWENB[2] TWENB[3] TWENB[4] TWENB[5] TWENB[6]
+  TWENB[7] TWENB[8] TWENB[9] TWENB[10] TWENB[11] TWENB[12] TWENB[13]
+  TWENB[14] TWENB[15] VNWC VNWP VNWC VNWP VPW VPW VPW WENA[0] WENA[1] WENA[2]
+  WENA[3] WENA[4] WENA[5] WENA[6] WENA[7] WENA[8] WENA[9] WENA[10] WENA[11]
+  WENA[12] WENA[13] WENA[14] WENA[15] WENB[0] WENB[1] WENB[2] WENB[3] WENB[4]
+  WENB[5] WENB[6] WENB[7] WENB[8] WENB[9] WENB[10] WENB[11] WENB[12] WENB[13]
+  WENB[14] WENB[15] WENYA[0] WENYA[1] WENYA[2] WENYA[3] WENYA[4] WENYA[5]
+  WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11] WENYA[12] WENYA[13]
+  WENYA[14] WENYA[15] WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5]
+  WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13]
+  WENYB[14] WENYB[15] CAA[2] ACT_CTLM SRAMdpw64d256CNTL_1V
.ENDS SRAMdpw64d256CNTL1VR64M4
****
.SUBCKT SRAMdpw64d256PIN_SIG DA DB QA QB TDA TDB TWENA TWENB VDDCE VDDPE VNWP
+  VPW VSS VSSE WENA WENB WENYA WENYB
** SRAMdpw64d256PIN_SIG: 8 flat devices **
DI31_0.D_Diode_X_dio VPW WENB NDIO11LL AREA=0.035P PJ=0.78U
DI31_1.D_Diode_X_dio VPW TWENB NDIO11LL AREA=0.035P PJ=0.78U
DI31_2.D_Diode_X_dio VPW DB NDIO11LL AREA=0.035P PJ=0.78U
DI31_3.D_Diode_X_dio VPW TDB NDIO11LL AREA=0.035P PJ=0.78U
DI32_0.D_Diode_X_dio VPW WENA NDIO11LL AREA=0.035P PJ=0.78U
DI32_1.D_Diode_X_dio VPW TWENA NDIO11LL AREA=0.035P PJ=0.78U
DI32_2.D_Diode_X_dio VPW DA NDIO11LL AREA=0.035P PJ=0.78U
DI32_3.D_Diode_X_dio VPW TDA NDIO11LL AREA=0.035P PJ=0.78U
.ENDS SRAMdpw64d256PIN_SIG
****
.SUBCKT SRAMdpw64d256PINSEC24M4 DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DA_8
+  DA_9 DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16 DA_17 DA_18 DA_19 DA_20
+  DA_21 DA_22 DA_23 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10
+  DB_11 DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20 DB_21 DB_22
+  DB_23 QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA_8 QA_9 QA_10 QA_11 QA_12
+  QA_13 QA_14 QA_15 QA_16 QA_17 QA_18 QA_19 QA_20 QA_21 QA_22 QA_23 QB_0 QB_1
+  QB_2 QB_3 QB_4 QB_5 QB_6 QB_7 QB_8 QB_9 QB_10 QB_11 QB_12 QB_13 QB_14 QB_15
+  QB_16 QB_17 QB_18 QB_19 QB_20 QB_21 QB_22 QB_23 TDA_0 TDA_1 TDA_2 TDA_3
+  TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13 TDA_14
+  TDA_15 TDA_16 TDA_17 TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23 TDB_0 TDB_1
+  TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7 TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13
+  TDB_14 TDB_15 TDB_16 TDB_17 TDB_18 TDB_19 TDB_20 TDB_21 TDB_22 TDB_23
+  TWENA_0 TWENA_1 TWENA_2 TWENA_3 TWENA_4 TWENA_5 TWENA_6 TWENA_7 TWENA_8
+  TWENA_9 TWENA_10 TWENA_11 TWENA_12 TWENA_13 TWENA_14 TWENA_15 TWENA_16
+  TWENA_17 TWENA_18 TWENA_19 TWENA_20 TWENA_21 TWENA_22 TWENA_23 TWENB_0
+  TWENB_1 TWENB_2 TWENB_3 TWENB_4 TWENB_5 TWENB_6 TWENB_7 TWENB_8 TWENB_9
+  TWENB_10 TWENB_11 TWENB_12 TWENB_13 TWENB_14 TWENB_15 TWENB_16 TWENB_17
+  TWENB_18 TWENB_19 TWENB_20 TWENB_21 TWENB_22 TWENB_23 VDDCE_0 VDDCE_1
+  VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7 VDDCE_8 VDDCE_9 VDDCE_10
+  VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15 VDDCE_16 VDDCE_17 VDDCE_18
+  VDDCE_19 VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23 VDDPE VNWP VPW VSS WENA_0
+  WENA_1 WENA_2 WENA_3 WENA_4 WENA_5 WENA_6 WENA_7 WENA_8 WENA_9 WENA_10
+  WENA_11 WENA_12 WENA_13 WENA_14 WENA_15 WENA_16 WENA_17 WENA_18 WENA_19
+  WENA_20 WENA_21 WENA_22 WENA_23 WENB_0 WENB_1 WENB_2 WENB_3 WENB_4 WENB_5
+  WENB_6 WENB_7 WENB_8 WENB_9 WENB_10 WENB_11 WENB_12 WENB_13 WENB_14 WENB_15
+  WENB_16 WENB_17 WENB_18 WENB_19 WENB_20 WENB_21 WENB_22 WENB_23 WENYA_0
+  WENYA_1 WENYA_2 WENYA_3 WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9
+  WENYA_10 WENYA_11 WENYA_12 WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17
+  WENYA_18 WENYA_19 WENYA_20 WENYA_21 WENYA_22 WENYA_23 WENYB_0 WENYB_1
+  WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10
+  WENYB_11 WENYB_12 WENYB_13 WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18
+  WENYB_19 WENYB_20 WENYB_21 WENYB_22 WENYB_23
** SRAMdpw64d256PINSEC24M4: 192 flat devices **
XPIN_SIGLSB0 DA_23 DB_23 QA_23 QB_23 TDA_23 TDB_23 TWENA_23 TWENB_23 VDDCE_23
+  VDDPE VNWP VPW VSS VSS WENA_23 WENB_23 WENYA_23 WENYB_23
+  SRAMdpw64d256PIN_SIG
XPIN_SIGLSB1 DA_22 DB_22 QA_22 QB_22 TDA_22 TDB_22 TWENA_22 TWENB_22 VDDCE_22
+  VDDPE VNWP VPW VSS VSS WENA_22 WENB_22 WENYA_22 WENYB_22
+  SRAMdpw64d256PIN_SIG
XPIN_SIGLSB2 DA_21 DB_21 QA_21 QB_21 TDA_21 TDB_21 TWENA_21 TWENB_21 VDDCE_21
+  VDDPE VNWP VPW VSS VSS WENA_21 WENB_21 WENYA_21 WENYB_21
+  SRAMdpw64d256PIN_SIG
XPIN_SIGLSB3 DA_20 DB_20 QA_20 QB_20 TDA_20 TDB_20 TWENA_20 TWENB_20 VDDCE_20
+  VDDPE VNWP VPW VSS VSS WENA_20 WENB_20 WENYA_20 WENYB_20
+  SRAMdpw64d256PIN_SIG
XPIN_SIGMSB0 DA_3 DB_3 QA_3 QB_3 TDA_3 TDB_3 TWENA_3 TWENB_3 VDDCE_3 VDDPE
+  VNWP VPW VSS VSS WENA_3 WENB_3 WENYA_3 WENYB_3 SRAMdpw64d256PIN_SIG
XPIN_SIGMSB1 DA_2 DB_2 QA_2 QB_2 TDA_2 TDB_2 TWENA_2 TWENB_2 VDDCE_2 VDDPE
+  VNWP VPW VSS VSS WENA_2 WENB_2 WENYA_2 WENYB_2 SRAMdpw64d256PIN_SIG
XPIN_SIGMSB2 DA_1 DB_1 QA_1 QB_1 TDA_1 TDB_1 TWENA_1 TWENB_1 VDDCE_1 VDDPE
+  VNWP VPW VSS VSS WENA_1 WENB_1 WENYA_1 WENYB_1 SRAMdpw64d256PIN_SIG
XPIN_SIGMSB3 DA_0 DB_0 QA_0 QB_0 TDA_0 TDB_0 TWENA_0 TWENB_0 VDDCE_0 VDDPE
+  VNWP VPW VSS VSS WENA_0 WENB_0 WENYA_0 WENYB_0 SRAMdpw64d256PIN_SIG
XPIN_SIG[10] DA_13 DB_13 QA_13 QB_13 TDA_13 TDB_13 TWENA_13 TWENB_13 VDDCE_13
+  VDDPE VNWP VPW VSS VSS WENA_13 WENB_13 WENYA_13 WENYB_13
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[11] DA_12 DB_12 QA_12 QB_12 TDA_12 TDB_12 TWENA_12 TWENB_12 VDDCE_12
+  VDDPE VNWP VPW VSS VSS WENA_12 WENB_12 WENYA_12 WENYB_12
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[12] DA_11 DB_11 QA_11 QB_11 TDA_11 TDB_11 TWENA_11 TWENB_11 VDDCE_11
+  VDDPE VNWP VPW VSS VSS WENA_11 WENB_11 WENYA_11 WENYB_11
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[13] DA_10 DB_10 QA_10 QB_10 TDA_10 TDB_10 TWENA_10 TWENB_10 VDDCE_10
+  VDDPE VNWP VPW VSS VSS WENA_10 WENB_10 WENYA_10 WENYB_10
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[14] DA_9 DB_9 QA_9 QB_9 TDA_9 TDB_9 TWENA_9 TWENB_9 VDDCE_9 VDDPE
+  VNWP VPW VSS VSS WENA_9 WENB_9 WENYA_9 WENYB_9 SRAMdpw64d256PIN_SIG
XPIN_SIG[15] DA_8 DB_8 QA_8 QB_8 TDA_8 TDB_8 TWENA_8 TWENB_8 VDDCE_8 VDDPE
+  VNWP VPW VSS VSS WENA_8 WENB_8 WENYA_8 WENYB_8 SRAMdpw64d256PIN_SIG
XPIN_SIG[16] DA_7 DB_7 QA_7 QB_7 TDA_7 TDB_7 TWENA_7 TWENB_7 VDDCE_7 VDDPE
+  VNWP VPW VSS VSS WENA_7 WENB_7 WENYA_7 WENYB_7 SRAMdpw64d256PIN_SIG
XPIN_SIG[17] DA_6 DB_6 QA_6 QB_6 TDA_6 TDB_6 TWENA_6 TWENB_6 VDDCE_6 VDDPE
+  VNWP VPW VSS VSS WENA_6 WENB_6 WENYA_6 WENYB_6 SRAMdpw64d256PIN_SIG
XPIN_SIG[18] DA_5 DB_5 QA_5 QB_5 TDA_5 TDB_5 TWENA_5 TWENB_5 VDDCE_5 VDDPE
+  VNWP VPW VSS VSS WENA_5 WENB_5 WENYA_5 WENYB_5 SRAMdpw64d256PIN_SIG
XPIN_SIG[19] DA_4 DB_4 QA_4 QB_4 TDA_4 TDB_4 TWENA_4 TWENB_4 VDDCE_4 VDDPE
+  VNWP VPW VSS VSS WENA_4 WENB_4 WENYA_4 WENYB_4 SRAMdpw64d256PIN_SIG
XPIN_SIG[4] DA_19 DB_19 QA_19 QB_19 TDA_19 TDB_19 TWENA_19 TWENB_19 VDDCE_19
+  VDDPE VNWP VPW VSS VSS WENA_19 WENB_19 WENYA_19 WENYB_19
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[5] DA_18 DB_18 QA_18 QB_18 TDA_18 TDB_18 TWENA_18 TWENB_18 VDDCE_18
+  VDDPE VNWP VPW VSS VSS WENA_18 WENB_18 WENYA_18 WENYB_18
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[6] DA_17 DB_17 QA_17 QB_17 TDA_17 TDB_17 TWENA_17 TWENB_17 VDDCE_17
+  VDDPE VNWP VPW VSS VSS WENA_17 WENB_17 WENYA_17 WENYB_17
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[7] DA_16 DB_16 QA_16 QB_16 TDA_16 TDB_16 TWENA_16 TWENB_16 VDDCE_16
+  VDDPE VNWP VPW VSS VSS WENA_16 WENB_16 WENYA_16 WENYB_16
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[8] DA_15 DB_15 QA_15 QB_15 TDA_15 TDB_15 TWENA_15 TWENB_15 VDDCE_15
+  VDDPE VNWP VPW VSS VSS WENA_15 WENB_15 WENYA_15 WENYB_15
+  SRAMdpw64d256PIN_SIG
XPIN_SIG[9] DA_14 DB_14 QA_14 QB_14 TDA_14 TDB_14 TWENA_14 TWENB_14 VDDCE_14
+  VDDPE VNWP VPW VSS VSS WENA_14 WENB_14 WENYA_14 WENYB_14
+  SRAMdpw64d256PIN_SIG
.ENDS SRAMdpw64d256PINSEC24M4
****
.SUBCKT SRAMdpw64d256PIN_CNTL_1V CAA[0] CAA[1] CAA[2] CAA[3] CAB[0] CAB[1]
+  CAB[2] CAB[3] CAYA[0] CAYA[1] CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2]
+  CAYB[3] CENA CENB CENYA CENYB CLKA CLKB COLLDISN DA[0] DA[1] DA[2] DA[3]
+  DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14]
+  DA[15] DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10]
+  DB[11] DB[12] DB[13] DB[14] DB[15] DFTRAMBYP EMAA[0] EMAA[1] EMAA[2]
+  EMAB[0] EMAB[1] EMAB[2] EMAWA[0] EMAWA[1] EMAWB[0] EMAWB[1] GWENA GWENB
+  GWENYA GWENYB NC_ACTCLMP NC_ACT_CTLM NC_NACT NC_NFAST_ACT NC_NRETHVT
+  NC_NRETNVT NC_PGEN_N PENA PENB PENSIA PENSIB PENSOA PENSOB PGEN PSOA[0]
+  PSOA[1] PSOB[0] PSOB[1] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7]
+  QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] QB[0] QB[1] QB[2]
+  QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+  QB[14] QB[15] RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAA[6] RAA[7]
+  RAA[8] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RAB[6] RAB[7] RAB[8]
+  RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4] RAYA[5] RAYA[6] RAYA[7] RAYA[8]
+  RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4] RAYB[5] RAYB[6] RAYB[7] RAYB[8]
+  RDTA RDTB RET1N RET2N SEA SEB SOA[0] SOA[1] SOB[0] SOB[1] TCAA[0] TCAA[1]
+  TCAA[2] TCAA[3] TCAB[0] TCAB[1] TCAB[2] TCAB[3] TCENA TCENB TDA[0] TDA[1]
+  TDA[2] TDA[3] TDA[4] TDA[5] TDA[6] TDA[7] TDA[8] TDA[9] TDA[10] TDA[11]
+  TDA[12] TDA[13] TDA[14] TDA[15] TDB[0] TDB[1] TDB[2] TDB[3] TDB[4] TDB[5]
+  TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12] TDB[13] TDB[14] TDB[15]
+  TENA TENB TGWENA TGWENB TPENA TPENB TRAA[0] TRAA[1] TRAA[2] TRAA[3] TRAA[4]
+  TRAA[5] TRAA[6] TRAA[7] TRAA[8] TRAB[0] TRAB[1] TRAB[2] TRAB[3] TRAB[4]
+  TRAB[5] TRAB[6] TRAB[7] TRAB[8] TWENA[0] TWENA[1] TWENA[2] TWENA[3]
+  TWENA[4] TWENA[5] TWENA[6] TWENA[7] TWENA[8] TWENA[9] TWENA[10] TWENA[11]
+  TWENA[12] TWENA[13] TWENA[14] TWENA[15] TWENB[0] TWENB[1] TWENB[2] TWENB[3]
+  TWENB[4] TWENB[5] TWENB[6] TWENB[7] TWENB[8] TWENB[9] TWENB[10] TWENB[11]
+  TWENB[12] TWENB[13] TWENB[14] TWENB[15] VDDCE VDDPE VNWC VNWP VPW VSS VSSE
+  WENA[0] WENA[1] WENA[2] WENA[3] WENA[4] WENA[5] WENA[6] WENA[7] WENA[8]
+  WENA[9] WENA[10] WENA[11] WENA[12] WENA[13] WENA[14] WENA[15] WENB[0]
+  WENB[1] WENB[2] WENB[3] WENB[4] WENB[5] WENB[6] WENB[7] WENB[8] WENB[9]
+  WENB[10] WENB[11] WENB[12] WENB[13] WENB[14] WENB[15] WENYA[0] WENYA[1]
+  WENYA[2] WENYA[3] WENYA[4] WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9]
+  WENYA[10] WENYA[11] WENYA[12] WENYA[13] WENYA[14] WENYA[15] WENYB[0]
+  WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5] WENYB[6] WENYB[7] WENYB[8]
+  WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13] WENYB[14] WENYB[15]
** SRAMdpw64d256PIN_CNTL_1V: 225 flat devices **
D0_0.D_Diode_X_dio VPW RET2N NDIO11LL AREA=0.035P PJ=0.78U
D0_1.D_Diode_X_dio VPW RET1N NDIO11LL AREA=0.035P PJ=0.78U
D0_2.D_Diode_X_dio VPW PGEN NDIO11LL AREA=0.035P PJ=0.78U
D0_3.D_Diode_X_dio VPW COLLDISN NDIO11LL AREA=0.035P PJ=0.78U
DI30_0.D_Diode_X_dio VPW PENSOB NDIO11LL AREA=0.035P PJ=0.78U
DI30_1.D_Diode_X_dio VPW PENSOA NDIO11LL AREA=0.035P PJ=0.78U
DI30_10.D_Diode_X_dio VPW SOA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI30_11.D_Diode_X_dio VPW SOA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI30_2.D_Diode_X_dio VPW PSOB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI30_3.D_Diode_X_dio VPW PSOB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI30_4.D_Diode_X_dio VPW PSOA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI30_5.D_Diode_X_dio VPW PSOA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI30_6.D_Diode_X_dio VPW SEB NDIO11LL AREA=0.035P PJ=0.78U
DI30_7.D_Diode_X_dio VPW SEA NDIO11LL AREA=0.035P PJ=0.78U
DI30_8.D_Diode_X_dio VPW SOB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI30_9.D_Diode_X_dio VPW SOB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI31_0.D_Diode_X_dio VPW WENA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI31_1.D_Diode_X_dio VPW WENA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI31_10.D_Diode_X_dio VPW WENA[10] NDIO11LL AREA=0.035P PJ=0.78U
DI31_11.D_Diode_X_dio VPW WENA[11] NDIO11LL AREA=0.035P PJ=0.78U
DI31_12.D_Diode_X_dio VPW WENA[12] NDIO11LL AREA=0.035P PJ=0.78U
DI31_13.D_Diode_X_dio VPW WENA[13] NDIO11LL AREA=0.035P PJ=0.78U
DI31_14.D_Diode_X_dio VPW WENA[14] NDIO11LL AREA=0.035P PJ=0.78U
DI31_15.D_Diode_X_dio VPW WENA[15] NDIO11LL AREA=0.035P PJ=0.78U
DI31_16.D_Diode_X_dio VPW TWENA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI31_17.D_Diode_X_dio VPW TWENA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI31_18.D_Diode_X_dio VPW TWENA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI31_19.D_Diode_X_dio VPW TWENA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI31_2.D_Diode_X_dio VPW WENA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI31_20.D_Diode_X_dio VPW TWENA[4] NDIO11LL AREA=0.035P PJ=0.78U
DI31_21.D_Diode_X_dio VPW TWENA[5] NDIO11LL AREA=0.035P PJ=0.78U
DI31_22.D_Diode_X_dio VPW TWENA[6] NDIO11LL AREA=0.035P PJ=0.78U
DI31_23.D_Diode_X_dio VPW TWENA[7] NDIO11LL AREA=0.035P PJ=0.78U
DI31_24.D_Diode_X_dio VPW TWENA[8] NDIO11LL AREA=0.035P PJ=0.78U
DI31_25.D_Diode_X_dio VPW TWENA[9] NDIO11LL AREA=0.035P PJ=0.78U
DI31_26.D_Diode_X_dio VPW TWENA[10] NDIO11LL AREA=0.035P PJ=0.78U
DI31_27.D_Diode_X_dio VPW TWENA[11] NDIO11LL AREA=0.035P PJ=0.78U
DI31_28.D_Diode_X_dio VPW TWENA[12] NDIO11LL AREA=0.035P PJ=0.78U
DI31_29.D_Diode_X_dio VPW TWENA[13] NDIO11LL AREA=0.035P PJ=0.78U
DI31_3.D_Diode_X_dio VPW WENA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI31_30.D_Diode_X_dio VPW TWENA[14] NDIO11LL AREA=0.035P PJ=0.78U
DI31_31.D_Diode_X_dio VPW TWENA[15] NDIO11LL AREA=0.035P PJ=0.78U
DI31_32.D_Diode_X_dio VPW DA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI31_33.D_Diode_X_dio VPW DA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI31_34.D_Diode_X_dio VPW DA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI31_35.D_Diode_X_dio VPW DA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI31_36.D_Diode_X_dio VPW DA[4] NDIO11LL AREA=0.035P PJ=0.78U
DI31_37.D_Diode_X_dio VPW DA[5] NDIO11LL AREA=0.035P PJ=0.78U
DI31_38.D_Diode_X_dio VPW DA[6] NDIO11LL AREA=0.035P PJ=0.78U
DI31_39.D_Diode_X_dio VPW DA[7] NDIO11LL AREA=0.035P PJ=0.78U
DI31_4.D_Diode_X_dio VPW WENA[4] NDIO11LL AREA=0.035P PJ=0.78U
DI31_40.D_Diode_X_dio VPW DA[8] NDIO11LL AREA=0.035P PJ=0.78U
DI31_41.D_Diode_X_dio VPW DA[9] NDIO11LL AREA=0.035P PJ=0.78U
DI31_42.D_Diode_X_dio VPW DA[10] NDIO11LL AREA=0.035P PJ=0.78U
DI31_43.D_Diode_X_dio VPW DA[11] NDIO11LL AREA=0.035P PJ=0.78U
DI31_44.D_Diode_X_dio VPW DA[12] NDIO11LL AREA=0.035P PJ=0.78U
DI31_45.D_Diode_X_dio VPW DA[13] NDIO11LL AREA=0.035P PJ=0.78U
DI31_46.D_Diode_X_dio VPW DA[14] NDIO11LL AREA=0.035P PJ=0.78U
DI31_47.D_Diode_X_dio VPW DA[15] NDIO11LL AREA=0.035P PJ=0.78U
DI31_48.D_Diode_X_dio VPW TDA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI31_49.D_Diode_X_dio VPW TDA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI31_5.D_Diode_X_dio VPW WENA[5] NDIO11LL AREA=0.035P PJ=0.78U
DI31_50.D_Diode_X_dio VPW TDA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI31_51.D_Diode_X_dio VPW TDA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI31_52.D_Diode_X_dio VPW TDA[4] NDIO11LL AREA=0.035P PJ=0.78U
DI31_53.D_Diode_X_dio VPW TDA[5] NDIO11LL AREA=0.035P PJ=0.78U
DI31_54.D_Diode_X_dio VPW TDA[6] NDIO11LL AREA=0.035P PJ=0.78U
DI31_55.D_Diode_X_dio VPW TDA[7] NDIO11LL AREA=0.035P PJ=0.78U
DI31_56.D_Diode_X_dio VPW TDA[8] NDIO11LL AREA=0.035P PJ=0.78U
DI31_57.D_Diode_X_dio VPW TDA[9] NDIO11LL AREA=0.035P PJ=0.78U
DI31_58.D_Diode_X_dio VPW TDA[10] NDIO11LL AREA=0.035P PJ=0.78U
DI31_59.D_Diode_X_dio VPW TDA[11] NDIO11LL AREA=0.035P PJ=0.78U
DI31_6.D_Diode_X_dio VPW WENA[6] NDIO11LL AREA=0.035P PJ=0.78U
DI31_60.D_Diode_X_dio VPW TDA[12] NDIO11LL AREA=0.035P PJ=0.78U
DI31_61.D_Diode_X_dio VPW TDA[13] NDIO11LL AREA=0.035P PJ=0.78U
DI31_62.D_Diode_X_dio VPW TDA[14] NDIO11LL AREA=0.035P PJ=0.78U
DI31_63.D_Diode_X_dio VPW TDA[15] NDIO11LL AREA=0.035P PJ=0.78U
DI31_7.D_Diode_X_dio VPW WENA[7] NDIO11LL AREA=0.035P PJ=0.78U
DI31_8.D_Diode_X_dio VPW WENA[8] NDIO11LL AREA=0.035P PJ=0.78U
DI31_9.D_Diode_X_dio VPW WENA[9] NDIO11LL AREA=0.035P PJ=0.78U
DI32_0.D_Diode_X_dio VPW WENB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI32_1.D_Diode_X_dio VPW WENB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI32_10.D_Diode_X_dio VPW WENB[10] NDIO11LL AREA=0.035P PJ=0.78U
DI32_11.D_Diode_X_dio VPW WENB[11] NDIO11LL AREA=0.035P PJ=0.78U
DI32_12.D_Diode_X_dio VPW WENB[12] NDIO11LL AREA=0.035P PJ=0.78U
DI32_13.D_Diode_X_dio VPW WENB[13] NDIO11LL AREA=0.035P PJ=0.78U
DI32_14.D_Diode_X_dio VPW WENB[14] NDIO11LL AREA=0.035P PJ=0.78U
DI32_15.D_Diode_X_dio VPW WENB[15] NDIO11LL AREA=0.035P PJ=0.78U
DI32_16.D_Diode_X_dio VPW TWENB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI32_17.D_Diode_X_dio VPW TWENB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI32_18.D_Diode_X_dio VPW TWENB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI32_19.D_Diode_X_dio VPW TWENB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI32_2.D_Diode_X_dio VPW WENB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI32_20.D_Diode_X_dio VPW TWENB[4] NDIO11LL AREA=0.035P PJ=0.78U
DI32_21.D_Diode_X_dio VPW TWENB[5] NDIO11LL AREA=0.035P PJ=0.78U
DI32_22.D_Diode_X_dio VPW TWENB[6] NDIO11LL AREA=0.035P PJ=0.78U
DI32_23.D_Diode_X_dio VPW TWENB[7] NDIO11LL AREA=0.035P PJ=0.78U
DI32_24.D_Diode_X_dio VPW TWENB[8] NDIO11LL AREA=0.035P PJ=0.78U
DI32_25.D_Diode_X_dio VPW TWENB[9] NDIO11LL AREA=0.035P PJ=0.78U
DI32_26.D_Diode_X_dio VPW TWENB[10] NDIO11LL AREA=0.035P PJ=0.78U
DI32_27.D_Diode_X_dio VPW TWENB[11] NDIO11LL AREA=0.035P PJ=0.78U
DI32_28.D_Diode_X_dio VPW TWENB[12] NDIO11LL AREA=0.035P PJ=0.78U
DI32_29.D_Diode_X_dio VPW TWENB[13] NDIO11LL AREA=0.035P PJ=0.78U
DI32_3.D_Diode_X_dio VPW WENB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI32_30.D_Diode_X_dio VPW TWENB[14] NDIO11LL AREA=0.035P PJ=0.78U
DI32_31.D_Diode_X_dio VPW TWENB[15] NDIO11LL AREA=0.035P PJ=0.78U
DI32_32.D_Diode_X_dio VPW DB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI32_33.D_Diode_X_dio VPW DB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI32_34.D_Diode_X_dio VPW DB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI32_35.D_Diode_X_dio VPW DB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI32_36.D_Diode_X_dio VPW DB[4] NDIO11LL AREA=0.035P PJ=0.78U
DI32_37.D_Diode_X_dio VPW DB[5] NDIO11LL AREA=0.035P PJ=0.78U
DI32_38.D_Diode_X_dio VPW DB[6] NDIO11LL AREA=0.035P PJ=0.78U
DI32_39.D_Diode_X_dio VPW DB[7] NDIO11LL AREA=0.035P PJ=0.78U
DI32_4.D_Diode_X_dio VPW WENB[4] NDIO11LL AREA=0.035P PJ=0.78U
DI32_40.D_Diode_X_dio VPW DB[8] NDIO11LL AREA=0.035P PJ=0.78U
DI32_41.D_Diode_X_dio VPW DB[9] NDIO11LL AREA=0.035P PJ=0.78U
DI32_42.D_Diode_X_dio VPW DB[10] NDIO11LL AREA=0.035P PJ=0.78U
DI32_43.D_Diode_X_dio VPW DB[11] NDIO11LL AREA=0.035P PJ=0.78U
DI32_44.D_Diode_X_dio VPW DB[12] NDIO11LL AREA=0.035P PJ=0.78U
DI32_45.D_Diode_X_dio VPW DB[13] NDIO11LL AREA=0.035P PJ=0.78U
DI32_46.D_Diode_X_dio VPW DB[14] NDIO11LL AREA=0.035P PJ=0.78U
DI32_47.D_Diode_X_dio VPW DB[15] NDIO11LL AREA=0.035P PJ=0.78U
DI32_48.D_Diode_X_dio VPW TDB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI32_49.D_Diode_X_dio VPW TDB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI32_5.D_Diode_X_dio VPW WENB[5] NDIO11LL AREA=0.035P PJ=0.78U
DI32_50.D_Diode_X_dio VPW TDB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI32_51.D_Diode_X_dio VPW TDB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI32_52.D_Diode_X_dio VPW TDB[4] NDIO11LL AREA=0.035P PJ=0.78U
DI32_53.D_Diode_X_dio VPW TDB[5] NDIO11LL AREA=0.035P PJ=0.78U
DI32_54.D_Diode_X_dio VPW TDB[6] NDIO11LL AREA=0.035P PJ=0.78U
DI32_55.D_Diode_X_dio VPW TDB[7] NDIO11LL AREA=0.035P PJ=0.78U
DI32_56.D_Diode_X_dio VPW TDB[8] NDIO11LL AREA=0.035P PJ=0.78U
DI32_57.D_Diode_X_dio VPW TDB[9] NDIO11LL AREA=0.035P PJ=0.78U
DI32_58.D_Diode_X_dio VPW TDB[10] NDIO11LL AREA=0.035P PJ=0.78U
DI32_59.D_Diode_X_dio VPW TDB[11] NDIO11LL AREA=0.035P PJ=0.78U
DI32_6.D_Diode_X_dio VPW WENB[6] NDIO11LL AREA=0.035P PJ=0.78U
DI32_60.D_Diode_X_dio VPW TDB[12] NDIO11LL AREA=0.035P PJ=0.78U
DI32_61.D_Diode_X_dio VPW TDB[13] NDIO11LL AREA=0.035P PJ=0.78U
DI32_62.D_Diode_X_dio VPW TDB[14] NDIO11LL AREA=0.035P PJ=0.78U
DI32_63.D_Diode_X_dio VPW TDB[15] NDIO11LL AREA=0.035P PJ=0.78U
DI32_7.D_Diode_X_dio VPW WENB[7] NDIO11LL AREA=0.035P PJ=0.78U
DI32_8.D_Diode_X_dio VPW WENB[8] NDIO11LL AREA=0.035P PJ=0.78U
DI32_9.D_Diode_X_dio VPW WENB[9] NDIO11LL AREA=0.035P PJ=0.78U
DI33_0.D_Diode_X_dio VPW TCAA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI33_1.D_Diode_X_dio VPW TCAA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI33_10.D_Diode_X_dio VPW TRAA[6] NDIO11LL AREA=0.035P PJ=0.78U
DI33_11.D_Diode_X_dio VPW TRAA[7] NDIO11LL AREA=0.035P PJ=0.78U
DI33_12.D_Diode_X_dio VPW TRAA[8] NDIO11LL AREA=0.035P PJ=0.78U
DI33_13.D_Diode_X_dio VPW CAA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI33_14.D_Diode_X_dio VPW CAA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI33_15.D_Diode_X_dio VPW CAA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI33_16.D_Diode_X_dio VPW CAA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI33_17.D_Diode_X_dio VPW RAA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI33_18.D_Diode_X_dio VPW RAA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI33_19.D_Diode_X_dio VPW RAA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI33_2.D_Diode_X_dio VPW TCAA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI33_20.D_Diode_X_dio VPW RAA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI33_21.D_Diode_X_dio VPW RAA[4] NDIO11LL AREA=0.035P PJ=0.78U
DI33_22.D_Diode_X_dio VPW RAA[5] NDIO11LL AREA=0.035P PJ=0.78U
DI33_23.D_Diode_X_dio VPW RAA[6] NDIO11LL AREA=0.035P PJ=0.78U
DI33_24.D_Diode_X_dio VPW RAA[7] NDIO11LL AREA=0.035P PJ=0.78U
DI33_25.D_Diode_X_dio VPW RAA[8] NDIO11LL AREA=0.035P PJ=0.78U
DI33_3.D_Diode_X_dio VPW TCAA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI33_4.D_Diode_X_dio VPW TRAA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI33_5.D_Diode_X_dio VPW TRAA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI33_6.D_Diode_X_dio VPW TRAA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI33_7.D_Diode_X_dio VPW TRAA[3] NDIO11LL AREA=0.035P PJ=0.78U
DI33_8.D_Diode_X_dio VPW TRAA[4] NDIO11LL AREA=0.035P PJ=0.78U
DI33_9.D_Diode_X_dio VPW TRAA[5] NDIO11LL AREA=0.035P PJ=0.78U
DI34_0.D_Diode_X_dio VPW TCAB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI34_1.D_Diode_X_dio VPW TCAB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI34_10.D_Diode_X_dio VPW TRAB[6] NDIO11LL AREA=0.035P PJ=0.78U
DI34_11.D_Diode_X_dio VPW TRAB[7] NDIO11LL AREA=0.035P PJ=0.78U
DI34_12.D_Diode_X_dio VPW TRAB[8] NDIO11LL AREA=0.035P PJ=0.78U
DI34_13.D_Diode_X_dio VPW CAB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI34_14.D_Diode_X_dio VPW CAB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI34_15.D_Diode_X_dio VPW CAB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI34_16.D_Diode_X_dio VPW CAB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI34_17.D_Diode_X_dio VPW RAB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI34_18.D_Diode_X_dio VPW RAB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI34_19.D_Diode_X_dio VPW RAB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI34_2.D_Diode_X_dio VPW TCAB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI34_20.D_Diode_X_dio VPW RAB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI34_21.D_Diode_X_dio VPW RAB[4] NDIO11LL AREA=0.035P PJ=0.78U
DI34_22.D_Diode_X_dio VPW RAB[5] NDIO11LL AREA=0.035P PJ=0.78U
DI34_23.D_Diode_X_dio VPW RAB[6] NDIO11LL AREA=0.035P PJ=0.78U
DI34_24.D_Diode_X_dio VPW RAB[7] NDIO11LL AREA=0.035P PJ=0.78U
DI34_25.D_Diode_X_dio VPW RAB[8] NDIO11LL AREA=0.035P PJ=0.78U
DI34_3.D_Diode_X_dio VPW TCAB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI34_4.D_Diode_X_dio VPW TRAB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI34_5.D_Diode_X_dio VPW TRAB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI34_6.D_Diode_X_dio VPW TRAB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI34_7.D_Diode_X_dio VPW TRAB[3] NDIO11LL AREA=0.035P PJ=0.78U
DI34_8.D_Diode_X_dio VPW TRAB[4] NDIO11LL AREA=0.035P PJ=0.78U
DI34_9.D_Diode_X_dio VPW TRAB[5] NDIO11LL AREA=0.035P PJ=0.78U
DI35_0.D_Diode_X_dio VPW CLKA NDIO11LL AREA=0.035P PJ=0.78U
DI35_1.D_Diode_X_dio VPW EMAA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI35_2.D_Diode_X_dio VPW EMAA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI35_3.D_Diode_X_dio VPW EMAA[2] NDIO11LL AREA=0.035P PJ=0.78U
DI35_4.D_Diode_X_dio VPW EMAWA[0] NDIO11LL AREA=0.035P PJ=0.78U
DI35_5.D_Diode_X_dio VPW EMAWA[1] NDIO11LL AREA=0.035P PJ=0.78U
DI35_6.D_Diode_X_dio VPW RDTA NDIO11LL AREA=0.035P PJ=0.78U
DI36_0.D_Diode_X_dio VPW CLKB NDIO11LL AREA=0.035P PJ=0.78U
DI36_1.D_Diode_X_dio VPW EMAB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI36_2.D_Diode_X_dio VPW EMAB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI36_3.D_Diode_X_dio VPW EMAB[2] NDIO11LL AREA=0.035P PJ=0.78U
DI36_4.D_Diode_X_dio VPW EMAWB[0] NDIO11LL AREA=0.035P PJ=0.78U
DI36_5.D_Diode_X_dio VPW EMAWB[1] NDIO11LL AREA=0.035P PJ=0.78U
DI36_6.D_Diode_X_dio VPW RDTB NDIO11LL AREA=0.035P PJ=0.78U
DI37_0.D_Diode_X_dio VPW TGWENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_1.D_Diode_X_dio VPW TGWENA NDIO11LL AREA=0.035P PJ=0.78U
DI37_10.D_Diode_X_dio VPW PENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_11.D_Diode_X_dio VPW PENA NDIO11LL AREA=0.035P PJ=0.78U
DI37_12.D_Diode_X_dio VPW DFTRAMBYP NDIO11LL AREA=0.035P PJ=0.78U
DI37_13.D_Diode_X_dio VPW TENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_14.D_Diode_X_dio VPW TENA NDIO11LL AREA=0.035P PJ=0.78U
DI37_2.D_Diode_X_dio VPW GWENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_3.D_Diode_X_dio VPW GWENA NDIO11LL AREA=0.035P PJ=0.78U
DI37_4.D_Diode_X_dio VPW TCENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_5.D_Diode_X_dio VPW TCENA NDIO11LL AREA=0.035P PJ=0.78U
DI37_6.D_Diode_X_dio VPW CENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_7.D_Diode_X_dio VPW CENA NDIO11LL AREA=0.035P PJ=0.78U
DI37_8.D_Diode_X_dio VPW TPENB NDIO11LL AREA=0.035P PJ=0.78U
DI37_9.D_Diode_X_dio VPW TPENA NDIO11LL AREA=0.035P PJ=0.78U
.ENDS SRAMdpw64d256PIN_CNTL_1V
****
.SUBCKT SRAMdpw64d256EDGE_PIN PSIA PSIB SIA SIB VDDPE VNWC VNWP VPW VSS VSSE
** SRAMdpw64d256EDGE_PIN: 4 flat devices **
DI3_0.D_Diode_X_dio VPW PSIB NDIO11LL AREA=0.035P PJ=0.78U
DI3_1.D_Diode_X_dio VPW SIB NDIO11LL AREA=0.035P PJ=0.78U
DI3_2.D_Diode_X_dio VPW PSIA NDIO11LL AREA=0.035P PJ=0.78U
DI3_3.D_Diode_X_dio VPW SIA NDIO11LL AREA=0.035P PJ=0.78U
.ENDS SRAMdpw64d256EDGE_PIN
****
.SUBCKT SRAMdpw64d256PIN1VR64M4 CAA[0] CAA[1] CAA[2] CAA[3] CAB[0] CAB[1]
+  CAB[2] CAB[3] CAYA[0] CAYA[1] CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2]
+  CAYB[3] CENA CENB CENYA CENYB CLKA CLKB COLLDISN DA[0] DA[1] DA[2] DA[3]
+  DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14]
+  DA[15] DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12
+  DA_13 DA_14 DA_15 DA_16 DA_17 DA_18 DA_19 DA_20 DA_21 DA_22 DA_23 DA_24
+  DA_25 DA_26 DA_27 DA_28 DA_29 DA_30 DA_31 DA_32 DA_33 DA_34 DA_35 DA_36
+  DA_37 DA_38 DA_39 DA_40 DA_41 DA_42 DA_43 DA_44 DA_45 DA_46 DA_47 DB[0]
+  DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12]
+  DB[13] DB[14] DB[15] DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9
+  DB_10 DB_11 DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20 DB_21
+  DB_22 DB_23 DB_24 DB_25 DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 DB_32 DB_33
+  DB_34 DB_35 DB_36 DB_37 DB_38 DB_39 DB_40 DB_41 DB_42 DB_43 DB_44 DB_45
+  DB_46 DB_47 DFTRAMBYP EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2]
+  EMAWA[0] EMAWA[1] EMAWB[0] EMAWB[1] GWENA GWENB GWENYA GWENYB NC_ACTCLMP
+  NC_ACT_CTLM NC_NACT NC_NFAST_ACT NC_NRETHVT NC_NRETNVT NC_PGEN_N PENA PENB
+  PENSIA PENSIB PENSOA PENSOB PSIA_0 PSIA_1 PSIB_0 PSIB_1 PSOA[0] PSOA[1]
+  PSOB[0] PSOB[1] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9]
+  QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] QA_0 QA_1 QA_2 QA_3 QA_4 QA_5
+  QA_6 QA_7 QA_8 QA_9 QA_10 QA_11 QA_12 QA_13 QA_14 QA_15 QA_16 QA_17 QA_18
+  QA_19 QA_20 QA_21 QA_22 QA_23 QA_24 QA_25 QA_26 QA_27 QA_28 QA_29 QA_30
+  QA_31 QA_32 QA_33 QA_34 QA_35 QA_36 QA_37 QA_38 QA_39 QA_40 QA_41 QA_42
+  QA_43 QA_44 QA_45 QA_46 QA_47 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6]
+  QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB_0 QB_1 QB_2
+  QB_3 QB_4 QB_5 QB_6 QB_7 QB_8 QB_9 QB_10 QB_11 QB_12 QB_13 QB_14 QB_15
+  QB_16 QB_17 QB_18 QB_19 QB_20 QB_21 QB_22 QB_23 QB_24 QB_25 QB_26 QB_27
+  QB_28 QB_29 QB_30 QB_31 QB_32 QB_33 QB_34 QB_35 QB_36 QB_37 QB_38 QB_39
+  QB_40 QB_41 QB_42 QB_43 QB_44 QB_45 QB_46 QB_47 RAA[0] RAA[1] RAA[2] RAA[3]
+  RAA[4] RAA[5] RAA[6] RAA[7] RAA[8] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4]
+  RAB[5] RAB[6] RAB[7] RAB[8] RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4] RAYA[5]
+  RAYA[6] RAYA[7] RAYA[8] RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4] RAYB[5]
+  RAYB[6] RAYB[7] RAYB[8] RDTA RDTB RET1N RET2N SEA SEB SIA_0 SIA_1 SIB_0
+  SIB_1 SOA[0] SOA[1] SOB[0] SOB[1] TCAA[0] TCAA[1] TCAA[2] TCAA[3] TCAB[0]
+  TCAB[1] TCAB[2] TCAB[3] TCENA TCENB TDA[0] TDA[1] TDA[2] TDA[3] TDA[4]
+  TDA[5] TDA[6] TDA[7] TDA[8] TDA[9] TDA[10] TDA[11] TDA[12] TDA[13] TDA[14]
+  TDA[15] TDA_0 TDA_1 TDA_2 TDA_3 TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9 TDA_10
+  TDA_11 TDA_12 TDA_13 TDA_14 TDA_15 TDA_16 TDA_17 TDA_18 TDA_19 TDA_20
+  TDA_21 TDA_22 TDA_23 TDA_24 TDA_25 TDA_26 TDA_27 TDA_28 TDA_29 TDA_30
+  TDA_31 TDA_32 TDA_33 TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40
+  TDA_41 TDA_42 TDA_43 TDA_44 TDA_45 TDA_46 TDA_47 TDB[0] TDB[1] TDB[2]
+  TDB[3] TDB[4] TDB[5] TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12]
+  TDB[13] TDB[14] TDB[15] TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7
+  TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18
+  TDB_19 TDB_20 TDB_21 TDB_22 TDB_23 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28
+  TDB_29 TDB_30 TDB_31 TDB_32 TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38
+  TDB_39 TDB_40 TDB_41 TDB_42 TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TENA TENB
+  TGWENA TGWENB TPENA TPENB TRAA[0] TRAA[1] TRAA[2] TRAA[3] TRAA[4] TRAA[5]
+  TRAA[6] TRAA[7] TRAA[8] TRAB[0] TRAB[1] TRAB[2] TRAB[3] TRAB[4] TRAB[5]
+  TRAB[6] TRAB[7] TRAB[8] TWENA[0] TWENA[1] TWENA[2] TWENA[3] TWENA[4]
+  TWENA[5] TWENA[6] TWENA[7] TWENA[8] TWENA[9] TWENA[10] TWENA[11] TWENA[12]
+  TWENA[13] TWENA[14] TWENA[15] TWENA_0 TWENA_1 TWENA_2 TWENA_3 TWENA_4
+  TWENA_5 TWENA_6 TWENA_7 TWENA_8 TWENA_9 TWENA_10 TWENA_11 TWENA_12 TWENA_13
+  TWENA_14 TWENA_15 TWENA_16 TWENA_17 TWENA_18 TWENA_19 TWENA_20 TWENA_21
+  TWENA_22 TWENA_23 TWENA_24 TWENA_25 TWENA_26 TWENA_27 TWENA_28 TWENA_29
+  TWENA_30 TWENA_31 TWENA_32 TWENA_33 TWENA_34 TWENA_35 TWENA_36 TWENA_37
+  TWENA_38 TWENA_39 TWENA_40 TWENA_41 TWENA_42 TWENA_43 TWENA_44 TWENA_45
+  TWENA_46 TWENA_47 TWENB[0] TWENB[1] TWENB[2] TWENB[3] TWENB[4] TWENB[5]
+  TWENB[6] TWENB[7] TWENB[8] TWENB[9] TWENB[10] TWENB[11] TWENB[12] TWENB[13]
+  TWENB[14] TWENB[15] TWENB_0 TWENB_1 TWENB_2 TWENB_3 TWENB_4 TWENB_5 TWENB_6
+  TWENB_7 TWENB_8 TWENB_9 TWENB_10 TWENB_11 TWENB_12 TWENB_13 TWENB_14
+  TWENB_15 TWENB_16 TWENB_17 TWENB_18 TWENB_19 TWENB_20 TWENB_21 TWENB_22
+  TWENB_23 TWENB_24 TWENB_25 TWENB_26 TWENB_27 TWENB_28 TWENB_29 TWENB_30
+  TWENB_31 TWENB_32 TWENB_33 TWENB_34 TWENB_35 TWENB_36 TWENB_37 TWENB_38
+  TWENB_39 TWENB_40 TWENB_41 TWENB_42 TWENB_43 TWENB_44 TWENB_45 TWENB_46
+  TWENB_47 VDDCE_0 VDDCE_1 VDDCE_2 VDDCE_3 VDDCE_4 VDDCE_5 VDDCE_6 VDDCE_7
+  VDDCE_8 VDDCE_9 VDDCE_10 VDDCE_11 VDDCE_12 VDDCE_13 VDDCE_14 VDDCE_15
+  VDDCE_16 VDDCE_17 VDDCE_18 VDDCE_19 VDDCE_20 VDDCE_21 VDDCE_22 VDDCE_23
+  VDDCE_24 VDDCE_25 VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31
+  VDDCE_32 VDDCE_33 VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39
+  VDDCE_40 VDDCE_41 VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47
+  VDDPE VNWC_0 VNWC_1 VNWC_2 VNWP VPW VSS WENA[0] WENA[1] WENA[2] WENA[3]
+  WENA[4] WENA[5] WENA[6] WENA[7] WENA[8] WENA[9] WENA[10] WENA[11] WENA[12]
+  WENA[13] WENA[14] WENA[15] WENA_0 WENA_1 WENA_2 WENA_3 WENA_4 WENA_5 WENA_6
+  WENA_7 WENA_8 WENA_9 WENA_10 WENA_11 WENA_12 WENA_13 WENA_14 WENA_15
+  WENA_16 WENA_17 WENA_18 WENA_19 WENA_20 WENA_21 WENA_22 WENA_23 WENA_24
+  WENA_25 WENA_26 WENA_27 WENA_28 WENA_29 WENA_30 WENA_31 WENA_32 WENA_33
+  WENA_34 WENA_35 WENA_36 WENA_37 WENA_38 WENA_39 WENA_40 WENA_41 WENA_42
+  WENA_43 WENA_44 WENA_45 WENA_46 WENA_47 WENB[0] WENB[1] WENB[2] WENB[3]
+  WENB[4] WENB[5] WENB[6] WENB[7] WENB[8] WENB[9] WENB[10] WENB[11] WENB[12]
+  WENB[13] WENB[14] WENB[15] WENB_0 WENB_1 WENB_2 WENB_3 WENB_4 WENB_5 WENB_6
+  WENB_7 WENB_8 WENB_9 WENB_10 WENB_11 WENB_12 WENB_13 WENB_14 WENB_15
+  WENB_16 WENB_17 WENB_18 WENB_19 WENB_20 WENB_21 WENB_22 WENB_23 WENB_24
+  WENB_25 WENB_26 WENB_27 WENB_28 WENB_29 WENB_30 WENB_31 WENB_32 WENB_33
+  WENB_34 WENB_35 WENB_36 WENB_37 WENB_38 WENB_39 WENB_40 WENB_41 WENB_42
+  WENB_43 WENB_44 WENB_45 WENB_46 WENB_47 WENYA[0] WENYA[1] WENYA[2] WENYA[3]
+  WENYA[4] WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11]
+  WENYA[12] WENYA[13] WENYA[14] WENYA[15] WENYA_0 WENYA_1 WENYA_2 WENYA_3
+  WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9 WENYA_10 WENYA_11 WENYA_12
+  WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17 WENYA_18 WENYA_19 WENYA_20
+  WENYA_21 WENYA_22 WENYA_23 WENYA_24 WENYA_25 WENYA_26 WENYA_27 WENYA_28
+  WENYA_29 WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35 WENYA_36
+  WENYA_37 WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43 WENYA_44
+  WENYA_45 WENYA_46 WENYA_47 WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4]
+  WENYB[5] WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12]
+  WENYB[13] WENYB[14] WENYB[15] WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4
+  WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13
+  WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21
+  WENYB_22 WENYB_23 WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29
+  WENYB_30 WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37
+  WENYB_38 WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45
+  WENYB_46 WENYB_47
** SRAMdpw64d256PIN1VR64M4: 617 flat devices **
XCTRL CAA[0] CAA[1] CAA[2] CAA[3] CAB[0] CAB[1] CAB[2] CAB[3] CAYA[0] CAYA[1]
+  CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2] CAYB[3] CENA CENB CENYA CENYB CLKA
+  CLKB COLLDISN DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8] DA[9]
+  DA[10] DA[11] DA[12] DA[13] DA[14] DA[15] DB[0] DB[1] DB[2] DB[3] DB[4]
+  DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12] DB[13] DB[14] DB[15]
+  DFTRAMBYP EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2] EMAWA[0] EMAWA[1]
+  EMAWB[0] EMAWB[1] GWENA GWENB GWENYA GWENYB NC_ACTCLMP NC_ACT_CTLM NC_NACT
+  NC_NFAST_ACT NC_NRETHVT NC_NRETNVT NC_PGEN_N PENA PENB PENSIA PENSIB PENSOA
+  PENSOB VSS PSOA[0] PSOA[1] PSOB[0] PSOB[1] QA[0] QA[1] QA[2] QA[3] QA[4]
+  QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14] QA[15]
+  QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+  QB[12] QB[13] QB[14] QB[15] RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5]
+  RAA[6] RAA[7] RAA[8] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] RAB[6]
+  RAB[7] RAB[8] RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4] RAYA[5] RAYA[6]
+  RAYA[7] RAYA[8] RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4] RAYB[5] RAYB[6]
+  RAYB[7] RAYB[8] RDTA RDTB RET1N RET2N SEA SEB SOA[0] SOA[1] SOB[0] SOB[1]
+  TCAA[0] TCAA[1] TCAA[2] TCAA[3] TCAB[0] TCAB[1] TCAB[2] TCAB[3] TCENA TCENB
+  TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5] TDA[6] TDA[7] TDA[8] TDA[9]
+  TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15] TDB[0] TDB[1] TDB[2] TDB[3]
+  TDB[4] TDB[5] TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12] TDB[13]
+  TDB[14] TDB[15] TENA TENB TGWENA TGWENB TPENA TPENB TRAA[0] TRAA[1] TRAA[2]
+  TRAA[3] TRAA[4] TRAA[5] TRAA[6] TRAA[7] TRAA[8] TRAB[0] TRAB[1] TRAB[2]
+  TRAB[3] TRAB[4] TRAB[5] TRAB[6] TRAB[7] TRAB[8] TWENA[0] TWENA[1] TWENA[2]
+  TWENA[3] TWENA[4] TWENA[5] TWENA[6] TWENA[7] TWENA[8] TWENA[9] TWENA[10]
+  TWENA[11] TWENA[12] TWENA[13] TWENA[14] TWENA[15] TWENB[0] TWENB[1]
+  TWENB[2] TWENB[3] TWENB[4] TWENB[5] TWENB[6] TWENB[7] TWENB[8] TWENB[9]
+  TWENB[10] TWENB[11] TWENB[12] TWENB[13] TWENB[14] TWENB[15] RET2N VDDPE
+  VNWC_1 VNWP VPW VSS VSS WENA[0] WENA[1] WENA[2] WENA[3] WENA[4] WENA[5]
+  WENA[6] WENA[7] WENA[8] WENA[9] WENA[10] WENA[11] WENA[12] WENA[13]
+  WENA[14] WENA[15] WENB[0] WENB[1] WENB[2] WENB[3] WENB[4] WENB[5] WENB[6]
+  WENB[7] WENB[8] WENB[9] WENB[10] WENB[11] WENB[12] WENB[13] WENB[14]
+  WENB[15] WENYA[0] WENYA[1] WENYA[2] WENYA[3] WENYA[4] WENYA[5] WENYA[6]
+  WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11] WENYA[12] WENYA[13]
+  WENYA[14] WENYA[15] WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5]
+  WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13]
+  WENYB[14] WENYB[15] SRAMdpw64d256PIN_CNTL_1V
XHCNTLL DA_23 DA_22 DA_21 DA_20 DA_19 DA_18 DA_17 DA_16 DA_15 DA_14 DA_13
+  DA_12 DA_11 DA_10 DA_9 DA_8 DA_7 DA_6 DA_5 DA_4 DA_3 DA_2 DA_1 DA_0 DB_23
+  DB_22 DB_21 DB_20 DB_19 DB_18 DB_17 DB_16 DB_15 DB_14 DB_13 DB_12 DB_11
+  DB_10 DB_9 DB_8 DB_7 DB_6 DB_5 DB_4 DB_3 DB_2 DB_1 DB_0 QA_23 QA_22 QA_21
+  QA_20 QA_19 QA_18 QA_17 QA_16 QA_15 QA_14 QA_13 QA_12 QA_11 QA_10 QA_9 QA_8
+  QA_7 QA_6 QA_5 QA_4 QA_3 QA_2 QA_1 QA_0 QB_23 QB_22 QB_21 QB_20 QB_19 QB_18
+  QB_17 QB_16 QB_15 QB_14 QB_13 QB_12 QB_11 QB_10 QB_9 QB_8 QB_7 QB_6 QB_5
+  QB_4 QB_3 QB_2 QB_1 QB_0 TDA_23 TDA_22 TDA_21 TDA_20 TDA_19 TDA_18 TDA_17
+  TDA_16 TDA_15 TDA_14 TDA_13 TDA_12 TDA_11 TDA_10 TDA_9 TDA_8 TDA_7 TDA_6
+  TDA_5 TDA_4 TDA_3 TDA_2 TDA_1 TDA_0 TDB_23 TDB_22 TDB_21 TDB_20 TDB_19
+  TDB_18 TDB_17 TDB_16 TDB_15 TDB_14 TDB_13 TDB_12 TDB_11 TDB_10 TDB_9 TDB_8
+  TDB_7 TDB_6 TDB_5 TDB_4 TDB_3 TDB_2 TDB_1 TDB_0 TWENA_23 TWENA_22 TWENA_21
+  TWENA_20 TWENA_19 TWENA_18 TWENA_17 TWENA_16 TWENA_15 TWENA_14 TWENA_13
+  TWENA_12 TWENA_11 TWENA_10 TWENA_9 TWENA_8 TWENA_7 TWENA_6 TWENA_5 TWENA_4
+  TWENA_3 TWENA_2 TWENA_1 TWENA_0 TWENB_23 TWENB_22 TWENB_21 TWENB_20
+  TWENB_19 TWENB_18 TWENB_17 TWENB_16 TWENB_15 TWENB_14 TWENB_13 TWENB_12
+  TWENB_11 TWENB_10 TWENB_9 TWENB_8 TWENB_7 TWENB_6 TWENB_5 TWENB_4 TWENB_3
+  TWENB_2 TWENB_1 TWENB_0 VDDCE_23 VDDCE_22 VDDCE_21 VDDCE_20 VDDCE_19
+  VDDCE_18 VDDCE_17 VDDCE_16 VDDCE_15 VDDCE_14 VDDCE_13 VDDCE_12 VDDCE_11
+  VDDCE_10 VDDCE_9 VDDCE_8 VDDCE_7 VDDCE_6 VDDCE_5 VDDCE_4 VDDCE_3 VDDCE_2
+  VDDCE_1 VDDCE_0 VDDPE VNWP VPW VSS WENA_23 WENA_22 WENA_21 WENA_20 WENA_19
+  WENA_18 WENA_17 WENA_16 WENA_15 WENA_14 WENA_13 WENA_12 WENA_11 WENA_10
+  WENA_9 WENA_8 WENA_7 WENA_6 WENA_5 WENA_4 WENA_3 WENA_2 WENA_1 WENA_0
+  WENB_23 WENB_22 WENB_21 WENB_20 WENB_19 WENB_18 WENB_17 WENB_16 WENB_15
+  WENB_14 WENB_13 WENB_12 WENB_11 WENB_10 WENB_9 WENB_8 WENB_7 WENB_6 WENB_5
+  WENB_4 WENB_3 WENB_2 WENB_1 WENB_0 WENYA_23 WENYA_22 WENYA_21 WENYA_20
+  WENYA_19 WENYA_18 WENYA_17 WENYA_16 WENYA_15 WENYA_14 WENYA_13 WENYA_12
+  WENYA_11 WENYA_10 WENYA_9 WENYA_8 WENYA_7 WENYA_6 WENYA_5 WENYA_4 WENYA_3
+  WENYA_2 WENYA_1 WENYA_0 WENYB_23 WENYB_22 WENYB_21 WENYB_20 WENYB_19
+  WENYB_18 WENYB_17 WENYB_16 WENYB_15 WENYB_14 WENYB_13 WENYB_12 WENYB_11
+  WENYB_10 WENYB_9 WENYB_8 WENYB_7 WENYB_6 WENYB_5 WENYB_4 WENYB_3 WENYB_2
+  WENYB_1 WENYB_0 SRAMdpw64d256PINSEC24M4
XHCNTLR DA_24 DA_25 DA_26 DA_27 DA_28 DA_29 DA_30 DA_31 DA_32 DA_33 DA_34
+  DA_35 DA_36 DA_37 DA_38 DA_39 DA_40 DA_41 DA_42 DA_43 DA_44 DA_45 DA_46
+  DA_47 DB_24 DB_25 DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 DB_32 DB_33 DB_34
+  DB_35 DB_36 DB_37 DB_38 DB_39 DB_40 DB_41 DB_42 DB_43 DB_44 DB_45 DB_46
+  DB_47 QA_24 QA_25 QA_26 QA_27 QA_28 QA_29 QA_30 QA_31 QA_32 QA_33 QA_34
+  QA_35 QA_36 QA_37 QA_38 QA_39 QA_40 QA_41 QA_42 QA_43 QA_44 QA_45 QA_46
+  QA_47 QB_24 QB_25 QB_26 QB_27 QB_28 QB_29 QB_30 QB_31 QB_32 QB_33 QB_34
+  QB_35 QB_36 QB_37 QB_38 QB_39 QB_40 QB_41 QB_42 QB_43 QB_44 QB_45 QB_46
+  QB_47 TDA_24 TDA_25 TDA_26 TDA_27 TDA_28 TDA_29 TDA_30 TDA_31 TDA_32 TDA_33
+  TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43
+  TDA_44 TDA_45 TDA_46 TDA_47 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28 TDB_29
+  TDB_30 TDB_31 TDB_32 TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38 TDB_39
+  TDB_40 TDB_41 TDB_42 TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TWENA_24 TWENA_25
+  TWENA_26 TWENA_27 TWENA_28 TWENA_29 TWENA_30 TWENA_31 TWENA_32 TWENA_33
+  TWENA_34 TWENA_35 TWENA_36 TWENA_37 TWENA_38 TWENA_39 TWENA_40 TWENA_41
+  TWENA_42 TWENA_43 TWENA_44 TWENA_45 TWENA_46 TWENA_47 TWENB_24 TWENB_25
+  TWENB_26 TWENB_27 TWENB_28 TWENB_29 TWENB_30 TWENB_31 TWENB_32 TWENB_33
+  TWENB_34 TWENB_35 TWENB_36 TWENB_37 TWENB_38 TWENB_39 TWENB_40 TWENB_41
+  TWENB_42 TWENB_43 TWENB_44 TWENB_45 TWENB_46 TWENB_47 VDDCE_24 VDDCE_25
+  VDDCE_26 VDDCE_27 VDDCE_28 VDDCE_29 VDDCE_30 VDDCE_31 VDDCE_32 VDDCE_33
+  VDDCE_34 VDDCE_35 VDDCE_36 VDDCE_37 VDDCE_38 VDDCE_39 VDDCE_40 VDDCE_41
+  VDDCE_42 VDDCE_43 VDDCE_44 VDDCE_45 VDDCE_46 VDDCE_47 VDDPE VNWP VPW VSS
+  WENA_24 WENA_25 WENA_26 WENA_27 WENA_28 WENA_29 WENA_30 WENA_31 WENA_32
+  WENA_33 WENA_34 WENA_35 WENA_36 WENA_37 WENA_38 WENA_39 WENA_40 WENA_41
+  WENA_42 WENA_43 WENA_44 WENA_45 WENA_46 WENA_47 WENB_24 WENB_25 WENB_26
+  WENB_27 WENB_28 WENB_29 WENB_30 WENB_31 WENB_32 WENB_33 WENB_34 WENB_35
+  WENB_36 WENB_37 WENB_38 WENB_39 WENB_40 WENB_41 WENB_42 WENB_43 WENB_44
+  WENB_45 WENB_46 WENB_47 WENYA_24 WENYA_25 WENYA_26 WENYA_27 WENYA_28
+  WENYA_29 WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35 WENYA_36
+  WENYA_37 WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43 WENYA_44
+  WENYA_45 WENYA_46 WENYA_47 WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28
+  WENYB_29 WENYB_30 WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36
+  WENYB_37 WENYB_38 WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44
+  WENYB_45 WENYB_46 WENYB_47 SRAMdpw64d256PINSEC24M4
XI4 PSIA_1 PSIB_1 SIA_1 SIB_1 VDDPE VNWC_2 VNWP VPW VSS VSS
+  SRAMdpw64d256EDGE_PIN
XPIN_EDGE PSIA_0 PSIB_0 SIA_0 SIB_0 VDDPE VNWC_0 VNWP VPW VSS VSS
+  SRAMdpw64d256EDGE_PIN
.ENDS SRAMdpw64d256PIN1VR64M4
****
.SUBCKT SRAMdpw64d256DPTH_RW_CM4 CLK_DP_A CLK_DP_B DA DB GTP_DWL ITWENA ITWENB
+  IWENA IWENB NC_VDDC NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]
+  NWGSEL_RED_B[0] Q_A Q_B RAM_A RAM_B SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1]
+  SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA SIB SOA SOB TDA TDB
+  TWENA TWENA_LSHF TWENA_RSHF TWENB TWENB_LSHF TWENB_RSHF VDDCE VDDPE VNWP
+  VPW VSS VSSE WDATAO_A[0] WDATAO_B[0] WENA WENA_LSHF WENA_RSHF WENB
+  WENB_LSHF WENB_RSHF WENYA WENYB WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3]
** SRAMdpw64d256DPTH_RW_CM4: 170 flat devices **
X_MI10.MXNA1 NCLK_DP_A CLK_DP_A VSS VPW N11LL_CKT W=0.19U L=0.04U
X_MI10.MXPA1 NCLK_DP_A CLK_DP_A VDDPE VNWP P11LL_CKT W=0.38U L=0.04U
X_MI44.MXNA1 BE_A NDFTRAMBYP_A VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MI44.MXPA1 BE_A NDFTRAMBYP_A VDDPE VNWP P11LL_CKT W=0.54U L=0.04U
X_MI45.MXNA1 BE_B NDFTRAMBYP_B VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MI45.MXPA1 BE_B NDFTRAMBYP_B VDDPE VNWP P11LL_CKT W=0.54U L=0.04U
X_MI52.MXNA1 NWGSEL_RED_A[0] WGSEL_RED_DLY_A VSS VPW N11LL_CKT W=1.215U
+  L=0.04U
X_MI52.MXPA1 NWGSEL_RED_A[0] WGSEL_RED_DLY_A VDDPE VNWP P11LL_CKT W=2.025U
+  L=0.04U
X_MI53.MXNA1 NWGSEL_RED_B[0] WGSEL_RED_DLY_B VSS VPW N11LL_CKT W=1.215U
+  L=0.04U
X_MI53.MXPA1 NWGSEL_RED_B[0] WGSEL_RED_DLY_B VDDPE VNWP P11LL_CKT W=2.025U
+  L=0.04U
X_MI54.MXNA1 NCLK_DP_B CLK_DP_B VSS VPW N11LL_CKT W=0.19U L=0.04U
X_MI54.MXPA1 NCLK_DP_B CLK_DP_B VDDPE VNWP P11LL_CKT W=0.38U L=0.04U
X_MIqdrva.I16.MXNA1 IQDRVA.NQ RAM_A VSS VPW N11LL_CKT W=0.92U L=0.04U
X_MIqdrva.I16.MXPA1 IQDRVA.NQ RAM_A VDDPE VNWP P11LL_CKT W=2.06U L=0.04U
X_MIqdrva.Iqso.MXNA1 SOA IQDRVA.NQ VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIqdrva.Iqso.MXPA1 SOA IQDRVA.NQ VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MIqdrva.MXN1 Q_A IQDRVA.NQ VSS VPW N11LL_CKT W=2.01U L=0.04U
X_MIqdrva.MXP1 Q_A IQDRVA.NQ VDDPE VNWP P11LL_CKT W=4.05U L=0.04U
X_MIqdrvb.I16.MXNA1 IQDRVB.NQ RAM_B VSS VPW N11LL_CKT W=0.92U L=0.04U
X_MIqdrvb.I16.MXPA1 IQDRVB.NQ RAM_B VDDPE VNWP P11LL_CKT W=2.06U L=0.04U
X_MIqdrvb.Iqso.MXNA1 SOB IQDRVB.NQ VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIqdrvb.Iqso.MXPA1 SOB IQDRVB.NQ VDDPE VNWP P11LL_CKT W=0.405U L=0.04U
X_MIqdrvb.MXN1 Q_B IQDRVB.NQ VSS VPW N11LL_CKT W=2.01U L=0.04U
X_MIqdrvb.MXP1 Q_B IQDRVB.NQ VDDPE VNWP P11LL_CKT W=4.05U L=0.04U
X_MIwdl_lata.I1.MXNA1 IWDL_LATA.BCLK NCLK_DP_A VSS VPW N11LL_CKT W=0.135U
+  L=0.04U
X_MIwdl_lata.I1.MXPA1 IWDL_LATA.BCLK NCLK_DP_A VDDPE VNWP P11LL_CKT W=0.27U
+  L=0.04U
X_MIwdl_lata.I3.MXNA1 WDATAO_A[0] IWDL_LATA.NET25 VSS VPW N11LL_CKT W=2.43U
+  L=0.04U
X_MIwdl_lata.I3.MXPA1 WDATAO_A[0] IWDL_LATA.NET25 VDDPE VNWP P11LL_CKT
+  W=4.015U L=0.04U
X_MIwdl_lata.I8.MXNA1 IWDL_LATA.NET25 IWDL_LATA.Q_INT VSS VPW N11LL_CKT
+  W=0.48U L=0.04U
X_MIwdl_lata.I8.MXPA1 IWDL_LATA.NET25 IWDL_LATA.Q_INT VDDPE VNWP P11LL_CKT
+  W=0.64U L=0.04U
X_MIwdl_lata.Ilat.I1_0.MXNA1 IWDL_LATA.ILAT.NSEL3 SEL_SI_A VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_lata.Ilat.I1_0.MXPA1 IWDL_LATA.ILAT.NSEL3 SEL_SI_A VDDPE VNWP
+  P11LL_CKT W=0.14U L=0.04U
X_MIwdl_lata.Ilat.I1_1.MXNA1 IWDL_LATA.ILAT.NSEL2 SEL_TD_A VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_lata.Ilat.I1_1.MXPA1 IWDL_LATA.ILAT.NSEL2 SEL_TD_A VDDPE VNWP
+  P11LL_CKT W=0.14U L=0.04U
X_MIwdl_lata.Ilat.I1_2.MXNA1 IWDL_LATA.ILAT.NSEL1 SEL_D_A VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_lata.Ilat.I1_2.MXPA1 IWDL_LATA.ILAT.NSEL1 SEL_D_A VDDPE VNWP P11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_lata.Ilat.I50.MXNA1 IWDL_LATA.Q_INT IWDL_LATA.NQ_INT VSS VPW N11LL_CKT
+  W=0.27U L=0.04U
X_MIwdl_lata.Ilat.I50.MXPA1 IWDL_LATA.Q_INT IWDL_LATA.NQ_INT VDDPE VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwdl_lata.Ilat.I55.MXNA1 IWDL_LATA.ILAT.I55.N1 IWDL_LATA.Q_INT VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_MIwdl_lata.Ilat.I55.MXNOE IWDL_LATA.NQ_INT IWDL_LATA.BCLK
+  IWDL_LATA.ILAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIwdl_lata.Ilat.I55.MXPA1 IWDL_LATA.ILAT.I55.P1 IWDL_LATA.Q_INT VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIwdl_lata.Ilat.I55.MXPOEN IWDL_LATA.NQ_INT NCLK_DP_A IWDL_LATA.ILAT.I55.P1
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwdl_lata.Ilat.I65.MXNOE IWDL_LATA.NQ_INT NCLK_DP_A IWDL_LATA.ILAT.ND VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.I65.MXPOEN IWDL_LATA.NQ_INT IWDL_LATA.BCLK IWDL_LATA.ILAT.ND
+  VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_lata.Ilat.MXN1 IWDL_LATA.ILAT.N2 TDA VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.MXN2 IWDL_LATA.ILAT.N1 DA VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.MXN3 IWDL_LATA.ILAT.ND SEL_D_A IWDL_LATA.ILAT.N1 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.MXN4 IWDL_LATA.ILAT.ND SEL_TD_A IWDL_LATA.ILAT.N2 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.MXN5 IWDL_LATA.ILAT.N3 SIA VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.MXN6 IWDL_LATA.ILAT.ND SEL_SI_A IWDL_LATA.ILAT.N3 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_lata.Ilat.MXP0 IWDL_LATA.ILAT.ND IWDL_LATA.ILAT.NSEL1
+  IWDL_LATA.ILAT.P1 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_lata.Ilat.MXP1 IWDL_LATA.ILAT.P1 DA VDDPE VNWP P11LL_CKT W=0.405U
+  L=0.04U
X_MIwdl_lata.Ilat.MXP2 IWDL_LATA.ILAT.ND IWDL_LATA.ILAT.NSEL2
+  IWDL_LATA.ILAT.P2 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_lata.Ilat.MXP3 IWDL_LATA.ILAT.P2 TDA VDDPE VNWP P11LL_CKT W=0.405U
+  L=0.04U
X_MIwdl_lata.Ilat.MXP4 IWDL_LATA.ILAT.ND IWDL_LATA.ILAT.NSEL3
+  IWDL_LATA.ILAT.P3 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_lata.Ilat.MXP5 IWDL_LATA.ILAT.P3 SIA VDDPE VNWP P11LL_CKT W=0.405U
+  L=0.04U
X_MIwdl_latb.I1.MXNA1 IWDL_LATB.BCLK NCLK_DP_B VSS VPW N11LL_CKT W=0.135U
+  L=0.04U
X_MIwdl_latb.I1.MXPA1 IWDL_LATB.BCLK NCLK_DP_B VDDPE VNWP P11LL_CKT W=0.27U
+  L=0.04U
X_MIwdl_latb.I3.MXNA1 WDATAO_B[0] IWDL_LATB.NET25 VSS VPW N11LL_CKT W=2.43U
+  L=0.04U
X_MIwdl_latb.I3.MXPA1 WDATAO_B[0] IWDL_LATB.NET25 VDDPE VNWP P11LL_CKT
+  W=4.015U L=0.04U
X_MIwdl_latb.I8.MXNA1 IWDL_LATB.NET25 IWDL_LATB.Q_INT VSS VPW N11LL_CKT
+  W=0.48U L=0.04U
X_MIwdl_latb.I8.MXPA1 IWDL_LATB.NET25 IWDL_LATB.Q_INT VDDPE VNWP P11LL_CKT
+  W=0.64U L=0.04U
X_MIwdl_latb.Ilat.I1_0.MXNA1 IWDL_LATB.ILAT.NSEL3 SEL_SI_B VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_latb.Ilat.I1_0.MXPA1 IWDL_LATB.ILAT.NSEL3 SEL_SI_B VDDPE VNWP
+  P11LL_CKT W=0.14U L=0.04U
X_MIwdl_latb.Ilat.I1_1.MXNA1 IWDL_LATB.ILAT.NSEL2 SEL_TD_B VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_latb.Ilat.I1_1.MXPA1 IWDL_LATB.ILAT.NSEL2 SEL_TD_B VDDPE VNWP
+  P11LL_CKT W=0.14U L=0.04U
X_MIwdl_latb.Ilat.I1_2.MXNA1 IWDL_LATB.ILAT.NSEL1 SEL_D_B VSS VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_latb.Ilat.I1_2.MXPA1 IWDL_LATB.ILAT.NSEL1 SEL_D_B VDDPE VNWP P11LL_CKT
+  W=0.14U L=0.04U
X_MIwdl_latb.Ilat.I50.MXNA1 IWDL_LATB.Q_INT IWDL_LATB.NQ_INT VSS VPW N11LL_CKT
+  W=0.27U L=0.04U
X_MIwdl_latb.Ilat.I50.MXPA1 IWDL_LATB.Q_INT IWDL_LATB.NQ_INT VDDPE VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwdl_latb.Ilat.I55.MXNA1 IWDL_LATB.ILAT.I55.N1 IWDL_LATB.Q_INT VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_MIwdl_latb.Ilat.I55.MXNOE IWDL_LATB.NQ_INT IWDL_LATB.BCLK
+  IWDL_LATB.ILAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIwdl_latb.Ilat.I55.MXPA1 IWDL_LATB.ILAT.I55.P1 IWDL_LATB.Q_INT VDDPE VNWP
+  P11LL_CKT W=0.15U L=0.04U
X_MIwdl_latb.Ilat.I55.MXPOEN IWDL_LATB.NQ_INT NCLK_DP_B IWDL_LATB.ILAT.I55.P1
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwdl_latb.Ilat.I65.MXNOE IWDL_LATB.NQ_INT NCLK_DP_B IWDL_LATB.ILAT.ND VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.I65.MXPOEN IWDL_LATB.NQ_INT IWDL_LATB.BCLK IWDL_LATB.ILAT.ND
+  VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_latb.Ilat.MXN1 IWDL_LATB.ILAT.N2 TDB VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.MXN2 IWDL_LATB.ILAT.N1 DB VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.MXN3 IWDL_LATB.ILAT.ND SEL_D_B IWDL_LATB.ILAT.N1 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.MXN4 IWDL_LATB.ILAT.ND SEL_TD_B IWDL_LATB.ILAT.N2 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.MXN5 IWDL_LATB.ILAT.N3 SIB VSS VPW N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.MXN6 IWDL_LATB.ILAT.ND SEL_SI_B IWDL_LATB.ILAT.N3 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwdl_latb.Ilat.MXP0 IWDL_LATB.ILAT.ND IWDL_LATB.ILAT.NSEL1
+  IWDL_LATB.ILAT.P1 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_latb.Ilat.MXP1 IWDL_LATB.ILAT.P1 DB VDDPE VNWP P11LL_CKT W=0.405U
+  L=0.04U
X_MIwdl_latb.Ilat.MXP2 IWDL_LATB.ILAT.ND IWDL_LATB.ILAT.NSEL2
+  IWDL_LATB.ILAT.P2 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_latb.Ilat.MXP3 IWDL_LATB.ILAT.P2 TDB VDDPE VNWP P11LL_CKT W=0.405U
+  L=0.04U
X_MIwdl_latb.Ilat.MXP4 IWDL_LATB.ILAT.ND IWDL_LATB.ILAT.NSEL3
+  IWDL_LATB.ILAT.P3 VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwdl_latb.Ilat.MXP5 IWDL_LATB.ILAT.P3 SIB VDDPE VNWP P11LL_CKT W=0.405U
+  L=0.04U
X_MIwen_muxlata.I19.MXNA1 IWEN_MUXLATA.TE NTE_A VSS VPW N11LL_CKT W=0.135U
+  L=0.04U
X_MIwen_muxlata.I19.MXPA1 IWEN_MUXLATA.TE NTE_A VDDPE VNWP P11LL_CKT W=0.2U
+  L=0.04U
X_MIwen_muxlata.I7.MXNA1 WGSEL_RED_A IWEN_MUXLATA.Q VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MIwen_muxlata.I7.MXPA1 WGSEL_RED_A IWEN_MUXLATA.Q VDDPE VNWP P11LL_CKT
+  W=0.81U L=0.04U
X_MIwen_muxlata.I9.MXNA1 IWEN_MUXLATA.BCLK NCLK_DP_A VSS VPW N11LL_CKT
+  W=0.135U L=0.04U
X_MIwen_muxlata.I9.MXPA1 IWEN_MUXLATA.BCLK NCLK_DP_A VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIwen_muxlata.Ilat.I0.MXNA1 IWEN_MUXLATA.ILAT.NDY IWEN_MUXLATA.ILAT.IDY
+  IWEN_MUXLATA.ILAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIwen_muxlata.Ilat.I0.MXNA2 IWEN_MUXLATA.ILAT.I0.N1 BE_A VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIwen_muxlata.Ilat.I0.MXPA1 IWEN_MUXLATA.ILAT.NDY IWEN_MUXLATA.ILAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIwen_muxlata.Ilat.I0.MXPA2 IWEN_MUXLATA.ILAT.NDY BE_A VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIwen_muxlata.Ilat.I50.MXNA1 IWEN_MUXLATA.Q IWEN_MUXLATA.NQ_INT VSS VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlata.Ilat.I50.MXPA1 IWEN_MUXLATA.Q IWEN_MUXLATA.NQ_INT VDDPE VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlata.Ilat.I55.MXNA1 IWEN_MUXLATA.ILAT.I55.N1 IWEN_MUXLATA.Q VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlata.Ilat.I55.MXNOE IWEN_MUXLATA.NQ_INT IWEN_MUXLATA.BCLK
+  IWEN_MUXLATA.ILAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlata.Ilat.I55.MXPA1 IWEN_MUXLATA.ILAT.I55.P1 IWEN_MUXLATA.Q VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlata.Ilat.I55.MXPOEN IWEN_MUXLATA.NQ_INT NCLK_DP_A
+  IWEN_MUXLATA.ILAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlata.Ilat.I57.MXNA1 IWEN_MUXLATA.ILAT.NSEL IWEN_MUXLATA.TE VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIwen_muxlata.Ilat.I57.MXPA1 IWEN_MUXLATA.ILAT.NSEL IWEN_MUXLATA.TE VDDPE
+  VNWP P11LL_CKT W=0.145U L=0.04U
X_MIwen_muxlata.Ilat.I62.MXNA1 WENYA IWEN_MUXLATA.ILAT.NDY VSS VPW N11LL_CKT
+  W=0.52U L=0.04U
X_MIwen_muxlata.Ilat.I62.MXPA1 WENYA IWEN_MUXLATA.ILAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.1U L=0.04U
X_MIwen_muxlata.Ilat.I63.MXNA1 IWEN_MUXLATA.ILAT.IDY IWEN_MUXLATA.ILAT.ND VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlata.Ilat.I63.MXPA1 IWEN_MUXLATA.ILAT.IDY IWEN_MUXLATA.ILAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlata.Ilat.I65.MXNOE IWEN_MUXLATA.NQ_INT NCLK_DP_A
+  IWEN_MUXLATA.ILAT.ND VPW N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlata.Ilat.I65.MXPOEN IWEN_MUXLATA.NQ_INT IWEN_MUXLATA.BCLK
+  IWEN_MUXLATA.ILAT.ND VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlata.Ilat.MXN1 IWEN_MUXLATA.ILAT.ND ITWENA IWEN_MUXLATA.ILAT.N2 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlata.Ilat.MXN2 IWEN_MUXLATA.ILAT.ND IWENA IWEN_MUXLATA.ILAT.N1 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlata.Ilat.MXN5 IWEN_MUXLATA.ILAT.N1 IWEN_MUXLATA.ILAT.NSEL VSS VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlata.Ilat.MXN6 IWEN_MUXLATA.ILAT.N2 IWEN_MUXLATA.TE VSS VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlata.Ilat.MXP1 IWEN_MUXLATA.ILAT.ND IWENA IWEN_MUXLATA.ILAT.P1 VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlata.Ilat.MXP3 IWEN_MUXLATA.ILAT.ND ITWENA IWEN_MUXLATA.ILAT.P2
+  VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlata.Ilat.MXP4 IWEN_MUXLATA.ILAT.P1 IWEN_MUXLATA.TE VDDPE VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlata.Ilat.MXP5 IWEN_MUXLATA.ILAT.P2 IWEN_MUXLATA.ILAT.NSEL VDDPE
+  VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlatb.I19.MXNA1 IWEN_MUXLATB.TE NTE_B VSS VPW N11LL_CKT W=0.135U
+  L=0.04U
X_MIwen_muxlatb.I19.MXPA1 IWEN_MUXLATB.TE NTE_B VDDPE VNWP P11LL_CKT W=0.2U
+  L=0.04U
X_MIwen_muxlatb.I7.MXNA1 WGSEL_RED_B IWEN_MUXLATB.Q VSS VPW N11LL_CKT W=0.4U
+  L=0.04U
X_MIwen_muxlatb.I7.MXPA1 WGSEL_RED_B IWEN_MUXLATB.Q VDDPE VNWP P11LL_CKT
+  W=0.81U L=0.04U
X_MIwen_muxlatb.I9.MXNA1 IWEN_MUXLATB.BCLK NCLK_DP_B VSS VPW N11LL_CKT
+  W=0.135U L=0.04U
X_MIwen_muxlatb.I9.MXPA1 IWEN_MUXLATB.BCLK NCLK_DP_B VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIwen_muxlatb.Ilat.I0.MXNA1 IWEN_MUXLATB.ILAT.NDY IWEN_MUXLATB.ILAT.IDY
+  IWEN_MUXLATB.ILAT.I0.N1 VPW N11LL_CKT W=0.17U L=0.04U
X_MIwen_muxlatb.Ilat.I0.MXNA2 IWEN_MUXLATB.ILAT.I0.N1 BE_B VSS VPW N11LL_CKT
+  W=0.17U L=0.04U
X_MIwen_muxlatb.Ilat.I0.MXPA1 IWEN_MUXLATB.ILAT.NDY IWEN_MUXLATB.ILAT.IDY
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIwen_muxlatb.Ilat.I0.MXPA2 IWEN_MUXLATB.ILAT.NDY BE_B VDDPE VNWP P11LL_CKT
+  W=0.17U L=0.04U
X_MIwen_muxlatb.Ilat.I50.MXNA1 IWEN_MUXLATB.Q IWEN_MUXLATB.NQ_INT VSS VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlatb.Ilat.I50.MXPA1 IWEN_MUXLATB.Q IWEN_MUXLATB.NQ_INT VDDPE VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlatb.Ilat.I55.MXNA1 IWEN_MUXLATB.ILAT.I55.N1 IWEN_MUXLATB.Q VSS VPW
+  N11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlatb.Ilat.I55.MXNOE IWEN_MUXLATB.NQ_INT IWEN_MUXLATB.BCLK
+  IWEN_MUXLATB.ILAT.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlatb.Ilat.I55.MXPA1 IWEN_MUXLATB.ILAT.I55.P1 IWEN_MUXLATB.Q VDDPE
+  VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlatb.Ilat.I55.MXPOEN IWEN_MUXLATB.NQ_INT NCLK_DP_B
+  IWEN_MUXLATB.ILAT.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlatb.Ilat.I57.MXNA1 IWEN_MUXLATB.ILAT.NSEL IWEN_MUXLATB.TE VSS VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIwen_muxlatb.Ilat.I57.MXPA1 IWEN_MUXLATB.ILAT.NSEL IWEN_MUXLATB.TE VDDPE
+  VNWP P11LL_CKT W=0.145U L=0.04U
X_MIwen_muxlatb.Ilat.I62.MXNA1 WENYB IWEN_MUXLATB.ILAT.NDY VSS VPW N11LL_CKT
+  W=0.52U L=0.04U
X_MIwen_muxlatb.Ilat.I62.MXPA1 WENYB IWEN_MUXLATB.ILAT.NDY VDDPE VNWP
+  P11LL_CKT W=1.1U L=0.04U
X_MIwen_muxlatb.Ilat.I63.MXNA1 IWEN_MUXLATB.ILAT.IDY IWEN_MUXLATB.ILAT.ND VSS
+  VPW N11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlatb.Ilat.I63.MXPA1 IWEN_MUXLATB.ILAT.IDY IWEN_MUXLATB.ILAT.ND
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIwen_muxlatb.Ilat.I65.MXNOE IWEN_MUXLATB.NQ_INT NCLK_DP_B
+  IWEN_MUXLATB.ILAT.ND VPW N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlatb.Ilat.I65.MXPOEN IWEN_MUXLATB.NQ_INT IWEN_MUXLATB.BCLK
+  IWEN_MUXLATB.ILAT.ND VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlatb.Ilat.MXN1 IWEN_MUXLATB.ILAT.ND ITWENB IWEN_MUXLATB.ILAT.N2 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlatb.Ilat.MXN2 IWEN_MUXLATB.ILAT.ND IWENB IWEN_MUXLATB.ILAT.N1 VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlatb.Ilat.MXN5 IWEN_MUXLATB.ILAT.N1 IWEN_MUXLATB.ILAT.NSEL VSS VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlatb.Ilat.MXN6 IWEN_MUXLATB.ILAT.N2 IWEN_MUXLATB.TE VSS VPW
+  N11LL_CKT W=0.27U L=0.04U
X_MIwen_muxlatb.Ilat.MXP1 IWEN_MUXLATB.ILAT.ND IWENB IWEN_MUXLATB.ILAT.P1 VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlatb.Ilat.MXP3 IWEN_MUXLATB.ILAT.ND ITWENB IWEN_MUXLATB.ILAT.P2
+  VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlatb.Ilat.MXP4 IWEN_MUXLATB.ILAT.P1 IWEN_MUXLATB.TE VDDPE VNWP
+  P11LL_CKT W=0.405U L=0.04U
X_MIwen_muxlatb.Ilat.MXP5 IWEN_MUXLATB.ILAT.P2 IWEN_MUXLATB.ILAT.NSEL VDDPE
+  VNWP P11LL_CKT W=0.405U L=0.04U
X_MIwendlya.MXN11 IWENDLYA.NET050 WGSEL_RED_A VSS VPW N11LL_CKT W=0.27U
+  L=0.04U
X_MIwendlya.MXN12 IWENDLYA.NDI1 WGSEL_RED_A IWENDLYA.NET050 VPW N11LL_CKT
+  W=0.27U L=0.04U
X_MIwendlya.MXN14 WGSEL_RED_DLY_A IWENDLYA.NDI1 IWENDLYA.NET069 VPW N11LL_CKT
+  W=0.405U L=0.04U
X_MIwendlya.MXN18 IWENDLYA.NET069 IWENDLYA.NDI1 VSS VPW N11LL_CKT W=0.405U
+  L=0.04U
X_MIwendlya.MXP11 IWENDLYA.NDI1 WGSEL_RED_A IWENDLYA.NET052 VNWP P11LL_CKT
+  W=0.27U L=0.04U
X_MIwendlya.MXP3 IWENDLYA.NET052 WGSEL_RED_A VDDPE VNWP P11LL_CKT W=0.27U
+  L=0.04U
X_MIwendlya.MXP6 WGSEL_RED_DLY_A IWENDLYA.NDI1 IWENDLYA.NET045 VNWP P11LL_CKT
+  W=0.81U L=0.04U
X_MIwendlya.MXP7 IWENDLYA.NET045 IWENDLYA.NDI1 VDDPE VNWP P11LL_CKT W=0.81U
+  L=0.04U
X_MIwendlyb.MXN11 IWENDLYB.NET050 WGSEL_RED_B VSS VPW N11LL_CKT W=0.27U
+  L=0.04U
X_MIwendlyb.MXN12 IWENDLYB.NDI1 WGSEL_RED_B IWENDLYB.NET050 VPW N11LL_CKT
+  W=0.27U L=0.04U
X_MIwendlyb.MXN14 WGSEL_RED_DLY_B IWENDLYB.NDI1 IWENDLYB.NET069 VPW N11LL_CKT
+  W=0.405U L=0.04U
X_MIwendlyb.MXN18 IWENDLYB.NET069 IWENDLYB.NDI1 VSS VPW N11LL_CKT W=0.405U
+  L=0.04U
X_MIwendlyb.MXP11 IWENDLYB.NDI1 WGSEL_RED_B IWENDLYB.NET052 VNWP P11LL_CKT
+  W=0.27U L=0.04U
X_MIwendlyb.MXP3 IWENDLYB.NET052 WGSEL_RED_B VDDPE VNWP P11LL_CKT W=0.27U
+  L=0.04U
X_MIwendlyb.MXP6 WGSEL_RED_DLY_B IWENDLYB.NDI1 IWENDLYB.NET045 VNWP P11LL_CKT
+  W=0.81U L=0.04U
X_MIwendlyb.MXP7 IWENDLYB.NET045 IWENDLYB.NDI1 VDDPE VNWP P11LL_CKT W=0.81U
+  L=0.04U
X_MXNpgl_0 VSS GTP_DWL VSS VPW N11LL_CKT W=1U L=0.07U
X_MXNpgl_1 VSS GTP_DWL VSS VPW N11LL_CKT W=1U L=0.07U
.ENDS SRAMdpw64d256DPTH_RW_CM4
****
.SUBCKT SRAMdpw64d256DPTHSEC0_32O4L CLK_DP_A CLK_DP_B DA_0 DA_1 DA_2 DA_3 DA_4
+  DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16 DA_17
+  DA_18 DA_19 DA_20 DA_21 DA_22 DA_23 DA_24 DA_25 DA_26 DA_27 DA_28 DA_29
+  DA_30 DA_31 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11
+  DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20 DB_21 DB_22 DB_23
+  DB_24 DB_25 DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 GTP_DWL NC_VDDC_0 NC_VDDC_1
+  NC_VDDC_2 NC_VDDC_3 NC_VDDC_4 NC_VDDC_5 NC_VDDC_6 NC_VDDC_7 NC_VDDC_8
+  NC_VDDC_9 NC_VDDC_10 NC_VDDC_11 NC_VDDC_12 NC_VDDC_13 NC_VDDC_14 NC_VDDC_15
+  NC_VDDC_16 NC_VDDC_17 NC_VDDC_18 NC_VDDC_19 NC_VDDC_20 NC_VDDC_21
+  NC_VDDC_22 NC_VDDC_23 NC_VDDC_24 NC_VDDC_25 NC_VDDC_26 NC_VDDC_27
+  NC_VDDC_28 NC_VDDC_29 NC_VDDC_30 NC_VDDC_31 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A
+  NTE_B NWGSEL_RED_A[0]_0 NWGSEL_RED_A[0]_1 NWGSEL_RED_A[0]_2
+  NWGSEL_RED_A[0]_3 NWGSEL_RED_A[0]_4 NWGSEL_RED_A[0]_5 NWGSEL_RED_A[0]_6
+  NWGSEL_RED_A[0]_7 NWGSEL_RED_A[0]_8 NWGSEL_RED_A[0]_9 NWGSEL_RED_A[0]_10
+  NWGSEL_RED_A[0]_11 NWGSEL_RED_A[0]_12 NWGSEL_RED_A[0]_13 NWGSEL_RED_A[0]_14
+  NWGSEL_RED_A[0]_15 NWGSEL_RED_A[0]_16 NWGSEL_RED_A[0]_17 NWGSEL_RED_A[0]_18
+  NWGSEL_RED_A[0]_19 NWGSEL_RED_A[0]_20 NWGSEL_RED_A[0]_21 NWGSEL_RED_A[0]_22
+  NWGSEL_RED_A[0]_23 NWGSEL_RED_A[0]_24 NWGSEL_RED_A[0]_25 NWGSEL_RED_A[0]_26
+  NWGSEL_RED_A[0]_27 NWGSEL_RED_A[0]_28 NWGSEL_RED_A[0]_29 NWGSEL_RED_A[0]_30
+  NWGSEL_RED_A[0]_31 NWGSEL_RED_B[0]_0 NWGSEL_RED_B[0]_1 NWGSEL_RED_B[0]_2
+  NWGSEL_RED_B[0]_3 NWGSEL_RED_B[0]_4 NWGSEL_RED_B[0]_5 NWGSEL_RED_B[0]_6
+  NWGSEL_RED_B[0]_7 NWGSEL_RED_B[0]_8 NWGSEL_RED_B[0]_9 NWGSEL_RED_B[0]_10
+  NWGSEL_RED_B[0]_11 NWGSEL_RED_B[0]_12 NWGSEL_RED_B[0]_13 NWGSEL_RED_B[0]_14
+  NWGSEL_RED_B[0]_15 NWGSEL_RED_B[0]_16 NWGSEL_RED_B[0]_17 NWGSEL_RED_B[0]_18
+  NWGSEL_RED_B[0]_19 NWGSEL_RED_B[0]_20 NWGSEL_RED_B[0]_21 NWGSEL_RED_B[0]_22
+  NWGSEL_RED_B[0]_23 NWGSEL_RED_B[0]_24 NWGSEL_RED_B[0]_25 NWGSEL_RED_B[0]_26
+  NWGSEL_RED_B[0]_27 NWGSEL_RED_B[0]_28 NWGSEL_RED_B[0]_29 NWGSEL_RED_B[0]_30
+  NWGSEL_RED_B[0]_31 Q_A_0 Q_A_1 Q_A_2 Q_A_3 Q_A_4 Q_A_5 Q_A_6 Q_A_7 Q_A_8
+  Q_A_9 Q_A_10 Q_A_11 Q_A_12 Q_A_13 Q_A_14 Q_A_15 Q_A_16 Q_A_17 Q_A_18 Q_A_19
+  Q_A_20 Q_A_21 Q_A_22 Q_A_23 Q_A_24 Q_A_25 Q_A_26 Q_A_27 Q_A_28 Q_A_29
+  Q_A_30 Q_A_31 Q_B_0 Q_B_1 Q_B_2 Q_B_3 Q_B_4 Q_B_5 Q_B_6 Q_B_7 Q_B_8 Q_B_9
+  Q_B_10 Q_B_11 Q_B_12 Q_B_13 Q_B_14 Q_B_15 Q_B_16 Q_B_17 Q_B_18 Q_B_19
+  Q_B_20 Q_B_21 Q_B_22 Q_B_23 Q_B_24 Q_B_25 Q_B_26 Q_B_27 Q_B_28 Q_B_29
+  Q_B_30 Q_B_31 RAM_A_0 RAM_A_1 RAM_A_2 RAM_A_3 RAM_A_4 RAM_A_5 RAM_A_6
+  RAM_A_7 RAM_A_8 RAM_A_9 RAM_A_10 RAM_A_11 RAM_A_12 RAM_A_13 RAM_A_14
+  RAM_A_15 RAM_A_16 RAM_A_17 RAM_A_18 RAM_A_19 RAM_A_20 RAM_A_21 RAM_A_22
+  RAM_A_23 RAM_A_24 RAM_A_25 RAM_A_26 RAM_A_27 RAM_A_28 RAM_A_29 RAM_A_30
+  RAM_A_31 RAM_B_0 RAM_B_1 RAM_B_2 RAM_B_3 RAM_B_4 RAM_B_5 RAM_B_6 RAM_B_7
+  RAM_B_8 RAM_B_9 RAM_B_10 RAM_B_11 RAM_B_12 RAM_B_13 RAM_B_14 RAM_B_15
+  RAM_B_16 RAM_B_17 RAM_B_18 RAM_B_19 RAM_B_20 RAM_B_21 RAM_B_22 RAM_B_23
+  RAM_B_24 RAM_B_25 RAM_B_26 RAM_B_27 RAM_B_28 RAM_B_29 RAM_B_30 RAM_B_31
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA SIB SOA SOB TDA_0 TDA_1 TDA_2 TDA_3 TDA_4 TDA_5 TDA_6
+  TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13 TDA_14 TDA_15 TDA_16 TDA_17
+  TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23 TDA_24 TDA_25 TDA_26 TDA_27
+  TDA_28 TDA_29 TDA_30 TDA_31 TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7
+  TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18
+  TDB_19 TDB_20 TDB_21 TDB_22 TDB_23 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28
+  TDB_29 TDB_30 TDB_31 TWENA_LSHF TWENB_LSHF VDDCE VDDPE VPW WDATAO_A[0]_0
+  WDATAO_A[0]_1 WDATAO_A[0]_2 WDATAO_A[0]_3 WDATAO_A[0]_4 WDATAO_A[0]_5
+  WDATAO_A[0]_6 WDATAO_A[0]_7 WDATAO_A[0]_8 WDATAO_A[0]_9 WDATAO_A[0]_10
+  WDATAO_A[0]_11 WDATAO_A[0]_12 WDATAO_A[0]_13 WDATAO_A[0]_14 WDATAO_A[0]_15
+  WDATAO_A[0]_16 WDATAO_A[0]_17 WDATAO_A[0]_18 WDATAO_A[0]_19 WDATAO_A[0]_20
+  WDATAO_A[0]_21 WDATAO_A[0]_22 WDATAO_A[0]_23 WDATAO_A[0]_24 WDATAO_A[0]_25
+  WDATAO_A[0]_26 WDATAO_A[0]_27 WDATAO_A[0]_28 WDATAO_A[0]_29 WDATAO_A[0]_30
+  WDATAO_A[0]_31 WDATAO_B[0]_0 WDATAO_B[0]_1 WDATAO_B[0]_2 WDATAO_B[0]_3
+  WDATAO_B[0]_4 WDATAO_B[0]_5 WDATAO_B[0]_6 WDATAO_B[0]_7 WDATAO_B[0]_8
+  WDATAO_B[0]_9 WDATAO_B[0]_10 WDATAO_B[0]_11 WDATAO_B[0]_12 WDATAO_B[0]_13
+  WDATAO_B[0]_14 WDATAO_B[0]_15 WDATAO_B[0]_16 WDATAO_B[0]_17 WDATAO_B[0]_18
+  WDATAO_B[0]_19 WDATAO_B[0]_20 WDATAO_B[0]_21 WDATAO_B[0]_22 WDATAO_B[0]_23
+  WDATAO_B[0]_24 WDATAO_B[0]_25 WDATAO_B[0]_26 WDATAO_B[0]_27 WDATAO_B[0]_28
+  WDATAO_B[0]_29 WDATAO_B[0]_30 WDATAO_B[0]_31 WENA_LSHF WENB_LSHF WENYA_0
+  WENYA_1 WENYA_2 WENYA_3 WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9
+  WENYA_10 WENYA_11 WENYA_12 WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17
+  WENYA_18 WENYA_19 WENYA_20 WENYA_21 WENYA_22 WENYA_23 WENYA_24 WENYA_25
+  WENYA_26 WENYA_27 WENYA_28 WENYA_29 WENYA_30 WENYA_31 WENYB_0 WENYB_1
+  WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10
+  WENYB_11 WENYB_12 WENYB_13 WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18
+  WENYB_19 WENYB_20 WENYB_21 WENYB_22 WENYB_23 WENYB_24 WENYB_25 WENYB_26
+  WENYB_27 WENYB_28 WENYB_29 WENYB_30 WENYB_31 WGSEL_A[0] WGSEL_A[1]
+  WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3]
** SRAMdpw64d256DPTHSEC0_32O4L: 5440 flat devices **
XDPTHMSB CLK_DP_A CLK_DP_B DA_0 DB_0 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_0 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_0
+  NWGSEL_RED_B[0]_0 Q_A_0 Q_B_0 RAM_A_0 RAM_B_0 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_72 SIB_74
+  SOA SOB TDA_0 TDB_0 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF
+  VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_0 WDATAO_B[0]_0 VPW WENA_LSHF
+  WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_0 WENYB_0 WGSEL_A[0] WGSEL_A[1]
+  WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3]
+  SRAMdpw64d256DPTH_RW_CM4
XDPTH[0] CLK_DP_A CLK_DP_B DA_31 DB_31 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_31 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_31 NWGSEL_RED_B[0]_31 Q_A_31 Q_B_31 RAM_A_31 RAM_B_31
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA SIB SOA_92 SOB_94 TDA_31 TDB_31 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_31 WDATAO_B[0]_31 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_31 WENYB_31 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[10] CLK_DP_A CLK_DP_B DA_21 DB_21 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_21 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_21 NWGSEL_RED_B[0]_21 Q_A_21 Q_B_21 RAM_A_21 RAM_B_21
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_0 SOB_2 SIA_12 SIB_14 TDA_21 TDB_21 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_21 WDATAO_B[0]_21 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_21 WENYB_21 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[11] CLK_DP_A CLK_DP_B DA_20 DB_20 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_20 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_20 NWGSEL_RED_B[0]_20 Q_A_20 Q_B_20 RAM_A_20 RAM_B_20
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_12 SIB_14 SOA_8 SOB_10 TDA_20 TDB_20 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_20 WDATAO_B[0]_20 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_20 WENYB_20 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[12] CLK_DP_A CLK_DP_B DA_19 DB_19 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_19 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_19 NWGSEL_RED_B[0]_19 Q_A_19 Q_B_19 RAM_A_19 RAM_B_19
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_8 SOB_10 SIA_28 SIB_30 TDA_19 TDB_19 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_19 WDATAO_B[0]_19 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_19 WENYB_19 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[13] CLK_DP_A CLK_DP_B DA_18 DB_18 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_18 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_18 NWGSEL_RED_B[0]_18 Q_A_18 Q_B_18 RAM_A_18 RAM_B_18
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_28 SIB_30 SOA_24 SOB_26 TDA_18 TDB_18 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_18 WDATAO_B[0]_18 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_18 WENYB_18 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[14] CLK_DP_A CLK_DP_B DA_17 DB_17 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_17 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_17 NWGSEL_RED_B[0]_17 Q_A_17 Q_B_17 RAM_A_17 RAM_B_17
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_24 SOB_26 SIA_44 SIB_46 TDA_17 TDB_17 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_17 WDATAO_B[0]_17 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_17 WENYB_17 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[15] CLK_DP_A CLK_DP_B DA_16 DB_16 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_16 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_16 NWGSEL_RED_B[0]_16 Q_A_16 Q_B_16 RAM_A_16 RAM_B_16
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_44 SIB_46 SOA_40 SOB_42 TDA_16 TDB_16 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_16 WDATAO_B[0]_16 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_16 WENYB_16 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[16] CLK_DP_A CLK_DP_B DA_15 DB_15 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_15 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_15 NWGSEL_RED_B[0]_15 Q_A_15 Q_B_15 RAM_A_15 RAM_B_15
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_40 SOB_42 SIA_60 SIB_62 TDA_15 TDB_15 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_15 WDATAO_B[0]_15 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_15 WENYB_15 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[17] CLK_DP_A CLK_DP_B DA_14 DB_14 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_14 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_14 NWGSEL_RED_B[0]_14 Q_A_14 Q_B_14 RAM_A_14 RAM_B_14
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_60 SIB_62 SOA_56 SOB_58 TDA_14 TDB_14 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_14 WDATAO_B[0]_14 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_14 WENYB_14 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[18] CLK_DP_A CLK_DP_B DA_13 DB_13 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_13 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_13 NWGSEL_RED_B[0]_13 Q_A_13 Q_B_13 RAM_A_13 RAM_B_13
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_56 SOB_58 SIA_80 SIB_82 TDA_13 TDB_13 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_13 WDATAO_B[0]_13 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_13 WENYB_13 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[19] CLK_DP_A CLK_DP_B DA_12 DB_12 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_12 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_12 NWGSEL_RED_B[0]_12 Q_A_12 Q_B_12 RAM_A_12 RAM_B_12
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_80 SIB_82 SOA_76 SOB_78 TDA_12 TDB_12 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_12 WDATAO_B[0]_12 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_12 WENYB_12 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[1] CLK_DP_A CLK_DP_B DA_30 DB_30 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_30 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_30 NWGSEL_RED_B[0]_30 Q_A_30 Q_B_30 RAM_A_30 RAM_B_30
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_92 SOB_94 SIA_100 SIB_102 TDA_30 TDB_30 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_30 WDATAO_B[0]_30 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_30 WENYB_30 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[20] CLK_DP_A CLK_DP_B DA_11 DB_11 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_11 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_11 NWGSEL_RED_B[0]_11 Q_A_11 Q_B_11 RAM_A_11 RAM_B_11
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_76 SOB_78 SIA_20 SIB_22 TDA_11 TDB_11 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_11 WDATAO_B[0]_11 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_11 WENYB_11 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[21] CLK_DP_A CLK_DP_B DA_10 DB_10 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_10 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_10 NWGSEL_RED_B[0]_10 Q_A_10 Q_B_10 RAM_A_10 RAM_B_10
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_20 SIB_22 SOA_16 SOB_18 TDA_10 TDB_10 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_10 WDATAO_B[0]_10 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_10 WENYB_10 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[22] CLK_DP_A CLK_DP_B DA_9 DB_9 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_9 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_9
+  NWGSEL_RED_B[0]_9 Q_A_9 Q_B_9 RAM_A_9 RAM_B_9 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_16 SOB_18
+  SIA_36 SIB_38 TDA_9 TDB_9 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_9 WDATAO_B[0]_9 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_9 WENYB_9 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[23] CLK_DP_A CLK_DP_B DA_8 DB_8 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_8 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_8
+  NWGSEL_RED_B[0]_8 Q_A_8 Q_B_8 RAM_A_8 RAM_B_8 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_36 SIB_38
+  SOA_32 SOB_34 TDA_8 TDB_8 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_8 WDATAO_B[0]_8 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_8 WENYB_8 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[24] CLK_DP_A CLK_DP_B DA_7 DB_7 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_7 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_7
+  NWGSEL_RED_B[0]_7 Q_A_7 Q_B_7 RAM_A_7 RAM_B_7 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_32 SOB_34
+  SIA_52 SIB_54 TDA_7 TDB_7 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_7 WDATAO_B[0]_7 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_7 WENYB_7 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[25] CLK_DP_A CLK_DP_B DA_6 DB_6 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_6 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_6
+  NWGSEL_RED_B[0]_6 Q_A_6 Q_B_6 RAM_A_6 RAM_B_6 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_52 SIB_54
+  SOA_48 SOB_50 TDA_6 TDB_6 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_6 WDATAO_B[0]_6 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_6 WENYB_6 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[26] CLK_DP_A CLK_DP_B DA_5 DB_5 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_5 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_5
+  NWGSEL_RED_B[0]_5 Q_A_5 Q_B_5 RAM_A_5 RAM_B_5 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_48 SOB_50
+  SIA_68 SIB_70 TDA_5 TDB_5 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_5 WDATAO_B[0]_5 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_5 WENYB_5 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[27] CLK_DP_A CLK_DP_B DA_4 DB_4 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_4 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_4
+  NWGSEL_RED_B[0]_4 Q_A_4 Q_B_4 RAM_A_4 RAM_B_4 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_68 SIB_70
+  SOA_64 SOB_66 TDA_4 TDB_4 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_4 WDATAO_B[0]_4 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_4 WENYB_4 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[28] CLK_DP_A CLK_DP_B DA_3 DB_3 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_3 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_3
+  NWGSEL_RED_B[0]_3 Q_A_3 Q_B_3 RAM_A_3 RAM_B_3 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_64 SOB_66
+  SIA_88 SIB_90 TDA_3 TDB_3 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_3 WDATAO_B[0]_3 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_3 WENYB_3 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[29] CLK_DP_A CLK_DP_B DA_2 DB_2 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_2 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_2
+  NWGSEL_RED_B[0]_2 Q_A_2 Q_B_2 RAM_A_2 RAM_B_2 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_88 SIB_90
+  SOA_84 SOB_86 TDA_2 TDB_2 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_2 WDATAO_B[0]_2 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_2 WENYB_2 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[2] CLK_DP_A CLK_DP_B DA_29 DB_29 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_29 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_29 NWGSEL_RED_B[0]_29 Q_A_29 Q_B_29 RAM_A_29 RAM_B_29
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_100 SIB_102 SOA_96 SOB_98 TDA_29 TDB_29 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_29 WDATAO_B[0]_29 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_29 WENYB_29 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[30] CLK_DP_A CLK_DP_B DA_1 DB_1 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_1 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_1
+  NWGSEL_RED_B[0]_1 Q_A_1 Q_B_1 RAM_A_1 RAM_B_1 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_84 SOB_86
+  SIA_72 SIB_74 TDA_1 TDB_1 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_1 WDATAO_B[0]_1 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_1 WENYB_1 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[3] CLK_DP_A CLK_DP_B DA_28 DB_28 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_28 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_28 NWGSEL_RED_B[0]_28 Q_A_28 Q_B_28 RAM_A_28 RAM_B_28
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_96 SOB_98 SIA_108 SIB_110 TDA_28 TDB_28 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_28 WDATAO_B[0]_28 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_28 WENYB_28 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[4] CLK_DP_A CLK_DP_B DA_27 DB_27 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_27 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_27 NWGSEL_RED_B[0]_27 Q_A_27 Q_B_27 RAM_A_27 RAM_B_27
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_108 SIB_110 SOA_104 SOB_106 TDA_27 TDB_27 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_27 WDATAO_B[0]_27 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_27 WENYB_27 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[5] CLK_DP_A CLK_DP_B DA_26 DB_26 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_26 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_26 NWGSEL_RED_B[0]_26 Q_A_26 Q_B_26 RAM_A_26 RAM_B_26
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_104 SOB_106 SIA_116 SIB_118 TDA_26 TDB_26 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_26 WDATAO_B[0]_26 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_26 WENYB_26 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[6] CLK_DP_A CLK_DP_B DA_25 DB_25 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_25 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_25 NWGSEL_RED_B[0]_25 Q_A_25 Q_B_25 RAM_A_25 RAM_B_25
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_116 SIB_118 SOA_112 SOB_114 TDA_25 TDB_25 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_25 WDATAO_B[0]_25 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_25 WENYB_25 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[7] CLK_DP_A CLK_DP_B DA_24 DB_24 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_24 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_24 NWGSEL_RED_B[0]_24 Q_A_24 Q_B_24 RAM_A_24 RAM_B_24
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_112 SOB_114 SIA_120 SIB_122 TDA_24 TDB_24 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_24 WDATAO_B[0]_24 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_24 WENYB_24 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[8] CLK_DP_A CLK_DP_B DA_23 DB_23 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_23 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_23 NWGSEL_RED_B[0]_23 Q_A_23 Q_B_23 RAM_A_23 RAM_B_23
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_120 SIB_122 SIA_4 SIB_6 TDA_23 TDB_23 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_23 WDATAO_B[0]_23 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_23 WENYB_23 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[9] CLK_DP_A CLK_DP_B DA_22 DB_22 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_22 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_22 NWGSEL_RED_B[0]_22 Q_A_22 Q_B_22 RAM_A_22 RAM_B_22
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_4 SIB_6 SOA_0 SOB_2 TDA_22 TDB_22 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_22 WDATAO_B[0]_22 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_22 WENYB_22 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
.ENDS SRAMdpw64d256DPTHSEC0_32O4L
****
.SUBCKT SRAMdpw64d256DPTHSEC0_32O4R CLK_DP_A CLK_DP_B DA_0 DA_1 DA_2 DA_3 DA_4
+  DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16 DA_17
+  DA_18 DA_19 DA_20 DA_21 DA_22 DA_23 DA_24 DA_25 DA_26 DA_27 DA_28 DA_29
+  DA_30 DA_31 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11
+  DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20 DB_21 DB_22 DB_23
+  DB_24 DB_25 DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 GTP_DWL NC_VDDC_0 NC_VDDC_1
+  NC_VDDC_2 NC_VDDC_3 NC_VDDC_4 NC_VDDC_5 NC_VDDC_6 NC_VDDC_7 NC_VDDC_8
+  NC_VDDC_9 NC_VDDC_10 NC_VDDC_11 NC_VDDC_12 NC_VDDC_13 NC_VDDC_14 NC_VDDC_15
+  NC_VDDC_16 NC_VDDC_17 NC_VDDC_18 NC_VDDC_19 NC_VDDC_20 NC_VDDC_21
+  NC_VDDC_22 NC_VDDC_23 NC_VDDC_24 NC_VDDC_25 NC_VDDC_26 NC_VDDC_27
+  NC_VDDC_28 NC_VDDC_29 NC_VDDC_30 NC_VDDC_31 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A
+  NTE_B NWGSEL_RED_A[0]_0 NWGSEL_RED_A[0]_1 NWGSEL_RED_A[0]_2
+  NWGSEL_RED_A[0]_3 NWGSEL_RED_A[0]_4 NWGSEL_RED_A[0]_5 NWGSEL_RED_A[0]_6
+  NWGSEL_RED_A[0]_7 NWGSEL_RED_A[0]_8 NWGSEL_RED_A[0]_9 NWGSEL_RED_A[0]_10
+  NWGSEL_RED_A[0]_11 NWGSEL_RED_A[0]_12 NWGSEL_RED_A[0]_13 NWGSEL_RED_A[0]_14
+  NWGSEL_RED_A[0]_15 NWGSEL_RED_A[0]_16 NWGSEL_RED_A[0]_17 NWGSEL_RED_A[0]_18
+  NWGSEL_RED_A[0]_19 NWGSEL_RED_A[0]_20 NWGSEL_RED_A[0]_21 NWGSEL_RED_A[0]_22
+  NWGSEL_RED_A[0]_23 NWGSEL_RED_A[0]_24 NWGSEL_RED_A[0]_25 NWGSEL_RED_A[0]_26
+  NWGSEL_RED_A[0]_27 NWGSEL_RED_A[0]_28 NWGSEL_RED_A[0]_29 NWGSEL_RED_A[0]_30
+  NWGSEL_RED_A[0]_31 NWGSEL_RED_B[0]_0 NWGSEL_RED_B[0]_1 NWGSEL_RED_B[0]_2
+  NWGSEL_RED_B[0]_3 NWGSEL_RED_B[0]_4 NWGSEL_RED_B[0]_5 NWGSEL_RED_B[0]_6
+  NWGSEL_RED_B[0]_7 NWGSEL_RED_B[0]_8 NWGSEL_RED_B[0]_9 NWGSEL_RED_B[0]_10
+  NWGSEL_RED_B[0]_11 NWGSEL_RED_B[0]_12 NWGSEL_RED_B[0]_13 NWGSEL_RED_B[0]_14
+  NWGSEL_RED_B[0]_15 NWGSEL_RED_B[0]_16 NWGSEL_RED_B[0]_17 NWGSEL_RED_B[0]_18
+  NWGSEL_RED_B[0]_19 NWGSEL_RED_B[0]_20 NWGSEL_RED_B[0]_21 NWGSEL_RED_B[0]_22
+  NWGSEL_RED_B[0]_23 NWGSEL_RED_B[0]_24 NWGSEL_RED_B[0]_25 NWGSEL_RED_B[0]_26
+  NWGSEL_RED_B[0]_27 NWGSEL_RED_B[0]_28 NWGSEL_RED_B[0]_29 NWGSEL_RED_B[0]_30
+  NWGSEL_RED_B[0]_31 Q_A_0 Q_A_1 Q_A_2 Q_A_3 Q_A_4 Q_A_5 Q_A_6 Q_A_7 Q_A_8
+  Q_A_9 Q_A_10 Q_A_11 Q_A_12 Q_A_13 Q_A_14 Q_A_15 Q_A_16 Q_A_17 Q_A_18 Q_A_19
+  Q_A_20 Q_A_21 Q_A_22 Q_A_23 Q_A_24 Q_A_25 Q_A_26 Q_A_27 Q_A_28 Q_A_29
+  Q_A_30 Q_A_31 Q_B_0 Q_B_1 Q_B_2 Q_B_3 Q_B_4 Q_B_5 Q_B_6 Q_B_7 Q_B_8 Q_B_9
+  Q_B_10 Q_B_11 Q_B_12 Q_B_13 Q_B_14 Q_B_15 Q_B_16 Q_B_17 Q_B_18 Q_B_19
+  Q_B_20 Q_B_21 Q_B_22 Q_B_23 Q_B_24 Q_B_25 Q_B_26 Q_B_27 Q_B_28 Q_B_29
+  Q_B_30 Q_B_31 RAM_A_0 RAM_A_1 RAM_A_2 RAM_A_3 RAM_A_4 RAM_A_5 RAM_A_6
+  RAM_A_7 RAM_A_8 RAM_A_9 RAM_A_10 RAM_A_11 RAM_A_12 RAM_A_13 RAM_A_14
+  RAM_A_15 RAM_A_16 RAM_A_17 RAM_A_18 RAM_A_19 RAM_A_20 RAM_A_21 RAM_A_22
+  RAM_A_23 RAM_A_24 RAM_A_25 RAM_A_26 RAM_A_27 RAM_A_28 RAM_A_29 RAM_A_30
+  RAM_A_31 RAM_B_0 RAM_B_1 RAM_B_2 RAM_B_3 RAM_B_4 RAM_B_5 RAM_B_6 RAM_B_7
+  RAM_B_8 RAM_B_9 RAM_B_10 RAM_B_11 RAM_B_12 RAM_B_13 RAM_B_14 RAM_B_15
+  RAM_B_16 RAM_B_17 RAM_B_18 RAM_B_19 RAM_B_20 RAM_B_21 RAM_B_22 RAM_B_23
+  RAM_B_24 RAM_B_25 RAM_B_26 RAM_B_27 RAM_B_28 RAM_B_29 RAM_B_30 RAM_B_31
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA SIB SOA SOB TDA_0 TDA_1 TDA_2 TDA_3 TDA_4 TDA_5 TDA_6
+  TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13 TDA_14 TDA_15 TDA_16 TDA_17
+  TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23 TDA_24 TDA_25 TDA_26 TDA_27
+  TDA_28 TDA_29 TDA_30 TDA_31 TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7
+  TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18
+  TDB_19 TDB_20 TDB_21 TDB_22 TDB_23 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28
+  TDB_29 TDB_30 TDB_31 TWENA_LSHF TWENB_LSHF VDDCE VDDPE VPW WDATAO_A[0]_0
+  WDATAO_A[0]_1 WDATAO_A[0]_2 WDATAO_A[0]_3 WDATAO_A[0]_4 WDATAO_A[0]_5
+  WDATAO_A[0]_6 WDATAO_A[0]_7 WDATAO_A[0]_8 WDATAO_A[0]_9 WDATAO_A[0]_10
+  WDATAO_A[0]_11 WDATAO_A[0]_12 WDATAO_A[0]_13 WDATAO_A[0]_14 WDATAO_A[0]_15
+  WDATAO_A[0]_16 WDATAO_A[0]_17 WDATAO_A[0]_18 WDATAO_A[0]_19 WDATAO_A[0]_20
+  WDATAO_A[0]_21 WDATAO_A[0]_22 WDATAO_A[0]_23 WDATAO_A[0]_24 WDATAO_A[0]_25
+  WDATAO_A[0]_26 WDATAO_A[0]_27 WDATAO_A[0]_28 WDATAO_A[0]_29 WDATAO_A[0]_30
+  WDATAO_A[0]_31 WDATAO_B[0]_0 WDATAO_B[0]_1 WDATAO_B[0]_2 WDATAO_B[0]_3
+  WDATAO_B[0]_4 WDATAO_B[0]_5 WDATAO_B[0]_6 WDATAO_B[0]_7 WDATAO_B[0]_8
+  WDATAO_B[0]_9 WDATAO_B[0]_10 WDATAO_B[0]_11 WDATAO_B[0]_12 WDATAO_B[0]_13
+  WDATAO_B[0]_14 WDATAO_B[0]_15 WDATAO_B[0]_16 WDATAO_B[0]_17 WDATAO_B[0]_18
+  WDATAO_B[0]_19 WDATAO_B[0]_20 WDATAO_B[0]_21 WDATAO_B[0]_22 WDATAO_B[0]_23
+  WDATAO_B[0]_24 WDATAO_B[0]_25 WDATAO_B[0]_26 WDATAO_B[0]_27 WDATAO_B[0]_28
+  WDATAO_B[0]_29 WDATAO_B[0]_30 WDATAO_B[0]_31 WENA_LSHF WENB_LSHF WENYA_0
+  WENYA_1 WENYA_2 WENYA_3 WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9
+  WENYA_10 WENYA_11 WENYA_12 WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17
+  WENYA_18 WENYA_19 WENYA_20 WENYA_21 WENYA_22 WENYA_23 WENYA_24 WENYA_25
+  WENYA_26 WENYA_27 WENYA_28 WENYA_29 WENYA_30 WENYA_31 WENYB_0 WENYB_1
+  WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10
+  WENYB_11 WENYB_12 WENYB_13 WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18
+  WENYB_19 WENYB_20 WENYB_21 WENYB_22 WENYB_23 WENYB_24 WENYB_25 WENYB_26
+  WENYB_27 WENYB_28 WENYB_29 WENYB_30 WENYB_31 WGSEL_A[0] WGSEL_A[1]
+  WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3]
** SRAMdpw64d256DPTHSEC0_32O4R: 5440 flat devices **
XDPTHMSB CLK_DP_A CLK_DP_B DA_0 DB_0 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_0 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_0
+  NWGSEL_RED_B[0]_0 Q_A_0 Q_B_0 RAM_A_0 RAM_B_0 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_72 SIB_74
+  SOA SOB TDA_0 TDB_0 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF
+  VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_0 WDATAO_B[0]_0 VPW WENA_LSHF
+  WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_0 WENYB_0 WGSEL_A[0] WGSEL_A[1]
+  WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3]
+  SRAMdpw64d256DPTH_RW_CM4
XDPTH[0] CLK_DP_A CLK_DP_B DA_31 DB_31 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_31 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_31 NWGSEL_RED_B[0]_31 Q_A_31 Q_B_31 RAM_A_31 RAM_B_31
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA SIB SOA_92 SOB_94 TDA_31 TDB_31 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_31 WDATAO_B[0]_31 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_31 WENYB_31 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[10] CLK_DP_A CLK_DP_B DA_21 DB_21 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_21 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_21 NWGSEL_RED_B[0]_21 Q_A_21 Q_B_21 RAM_A_21 RAM_B_21
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_0 SOB_2 SIA_12 SIB_14 TDA_21 TDB_21 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_21 WDATAO_B[0]_21 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_21 WENYB_21 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[11] CLK_DP_A CLK_DP_B DA_20 DB_20 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_20 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_20 NWGSEL_RED_B[0]_20 Q_A_20 Q_B_20 RAM_A_20 RAM_B_20
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_12 SIB_14 SOA_8 SOB_10 TDA_20 TDB_20 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_20 WDATAO_B[0]_20 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_20 WENYB_20 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[12] CLK_DP_A CLK_DP_B DA_19 DB_19 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_19 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_19 NWGSEL_RED_B[0]_19 Q_A_19 Q_B_19 RAM_A_19 RAM_B_19
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_8 SOB_10 SIA_28 SIB_30 TDA_19 TDB_19 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_19 WDATAO_B[0]_19 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_19 WENYB_19 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[13] CLK_DP_A CLK_DP_B DA_18 DB_18 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_18 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_18 NWGSEL_RED_B[0]_18 Q_A_18 Q_B_18 RAM_A_18 RAM_B_18
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_28 SIB_30 SOA_24 SOB_26 TDA_18 TDB_18 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_18 WDATAO_B[0]_18 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_18 WENYB_18 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[14] CLK_DP_A CLK_DP_B DA_17 DB_17 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_17 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_17 NWGSEL_RED_B[0]_17 Q_A_17 Q_B_17 RAM_A_17 RAM_B_17
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_24 SOB_26 SIA_44 SIB_46 TDA_17 TDB_17 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_17 WDATAO_B[0]_17 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_17 WENYB_17 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[15] CLK_DP_A CLK_DP_B DA_16 DB_16 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_16 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_16 NWGSEL_RED_B[0]_16 Q_A_16 Q_B_16 RAM_A_16 RAM_B_16
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_44 SIB_46 SOA_40 SOB_42 TDA_16 TDB_16 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_16 WDATAO_B[0]_16 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_16 WENYB_16 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[16] CLK_DP_A CLK_DP_B DA_15 DB_15 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_15 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_15 NWGSEL_RED_B[0]_15 Q_A_15 Q_B_15 RAM_A_15 RAM_B_15
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_40 SOB_42 SIA_60 SIB_62 TDA_15 TDB_15 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_15 WDATAO_B[0]_15 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_15 WENYB_15 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[17] CLK_DP_A CLK_DP_B DA_14 DB_14 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_14 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_14 NWGSEL_RED_B[0]_14 Q_A_14 Q_B_14 RAM_A_14 RAM_B_14
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_60 SIB_62 SOA_56 SOB_58 TDA_14 TDB_14 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_14 WDATAO_B[0]_14 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_14 WENYB_14 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[18] CLK_DP_A CLK_DP_B DA_13 DB_13 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_13 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_13 NWGSEL_RED_B[0]_13 Q_A_13 Q_B_13 RAM_A_13 RAM_B_13
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_56 SOB_58 SIA_80 SIB_82 TDA_13 TDB_13 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_13 WDATAO_B[0]_13 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_13 WENYB_13 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[19] CLK_DP_A CLK_DP_B DA_12 DB_12 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_12 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_12 NWGSEL_RED_B[0]_12 Q_A_12 Q_B_12 RAM_A_12 RAM_B_12
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_80 SIB_82 SOA_76 SOB_78 TDA_12 TDB_12 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_12 WDATAO_B[0]_12 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_12 WENYB_12 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[1] CLK_DP_A CLK_DP_B DA_30 DB_30 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_30 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_30 NWGSEL_RED_B[0]_30 Q_A_30 Q_B_30 RAM_A_30 RAM_B_30
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_92 SOB_94 SIA_100 SIB_102 TDA_30 TDB_30 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_30 WDATAO_B[0]_30 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_30 WENYB_30 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[20] CLK_DP_A CLK_DP_B DA_11 DB_11 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_11 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_11 NWGSEL_RED_B[0]_11 Q_A_11 Q_B_11 RAM_A_11 RAM_B_11
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_76 SOB_78 SIA_20 SIB_22 TDA_11 TDB_11 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_11 WDATAO_B[0]_11 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_11 WENYB_11 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[21] CLK_DP_A CLK_DP_B DA_10 DB_10 GTP_DWL TWENA_LSHF TWENB_LSHF
+  WENA_LSHF WENB_LSHF NC_VDDC_10 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_10 NWGSEL_RED_B[0]_10 Q_A_10 Q_B_10 RAM_A_10 RAM_B_10
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_20 SIB_22 SOA_16 SOB_18 TDA_10 TDB_10 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_10 WDATAO_B[0]_10 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_10 WENYB_10 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[22] CLK_DP_A CLK_DP_B DA_9 DB_9 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_9 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_9
+  NWGSEL_RED_B[0]_9 Q_A_9 Q_B_9 RAM_A_9 RAM_B_9 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_16 SOB_18
+  SIA_36 SIB_38 TDA_9 TDB_9 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_9 WDATAO_B[0]_9 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_9 WENYB_9 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[23] CLK_DP_A CLK_DP_B DA_8 DB_8 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_8 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_8
+  NWGSEL_RED_B[0]_8 Q_A_8 Q_B_8 RAM_A_8 RAM_B_8 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_36 SIB_38
+  SOA_32 SOB_34 TDA_8 TDB_8 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_8 WDATAO_B[0]_8 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_8 WENYB_8 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[24] CLK_DP_A CLK_DP_B DA_7 DB_7 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_7 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_7
+  NWGSEL_RED_B[0]_7 Q_A_7 Q_B_7 RAM_A_7 RAM_B_7 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_32 SOB_34
+  SIA_52 SIB_54 TDA_7 TDB_7 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_7 WDATAO_B[0]_7 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_7 WENYB_7 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[25] CLK_DP_A CLK_DP_B DA_6 DB_6 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_6 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_6
+  NWGSEL_RED_B[0]_6 Q_A_6 Q_B_6 RAM_A_6 RAM_B_6 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_52 SIB_54
+  SOA_48 SOB_50 TDA_6 TDB_6 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_6 WDATAO_B[0]_6 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_6 WENYB_6 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[26] CLK_DP_A CLK_DP_B DA_5 DB_5 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_5 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_5
+  NWGSEL_RED_B[0]_5 Q_A_5 Q_B_5 RAM_A_5 RAM_B_5 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_48 SOB_50
+  SIA_68 SIB_70 TDA_5 TDB_5 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_5 WDATAO_B[0]_5 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_5 WENYB_5 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[27] CLK_DP_A CLK_DP_B DA_4 DB_4 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_4 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_4
+  NWGSEL_RED_B[0]_4 Q_A_4 Q_B_4 RAM_A_4 RAM_B_4 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_68 SIB_70
+  SOA_64 SOB_66 TDA_4 TDB_4 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_4 WDATAO_B[0]_4 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_4 WENYB_4 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[28] CLK_DP_A CLK_DP_B DA_3 DB_3 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_3 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_3
+  NWGSEL_RED_B[0]_3 Q_A_3 Q_B_3 RAM_A_3 RAM_B_3 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_64 SOB_66
+  SIA_88 SIB_90 TDA_3 TDB_3 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_3 WDATAO_B[0]_3 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_3 WENYB_3 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[29] CLK_DP_A CLK_DP_B DA_2 DB_2 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_2 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_2
+  NWGSEL_RED_B[0]_2 Q_A_2 Q_B_2 RAM_A_2 RAM_B_2 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SIA_88 SIB_90
+  SOA_84 SOB_86 TDA_2 TDB_2 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_2 WDATAO_B[0]_2 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_2 WENYB_2 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[2] CLK_DP_A CLK_DP_B DA_29 DB_29 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_29 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_29 NWGSEL_RED_B[0]_29 Q_A_29 Q_B_29 RAM_A_29 RAM_B_29
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_100 SIB_102 SOA_96 SOB_98 TDA_29 TDB_29 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_29 WDATAO_B[0]_29 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_29 WENYB_29 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[30] CLK_DP_A CLK_DP_B DA_1 DB_1 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_1 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B NWGSEL_RED_A[0]_1
+  NWGSEL_RED_B[0]_1 Q_A_1 Q_B_1 RAM_A_1 RAM_B_1 SEL_A[0] SEL_A[1] SEL_B[0]
+  SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B SEL_TD_A SEL_TD_B SOA_84 SOB_86
+  SIA_72 SIB_74 TDA_1 TDB_1 VPW TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF
+  TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW WDATAO_A[0]_1 WDATAO_B[0]_1 VPW
+  WENA_LSHF WENA_LSHF VPW WENB_LSHF WENB_LSHF WENYA_1 WENYB_1 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[3] CLK_DP_A CLK_DP_B DA_28 DB_28 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_28 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_28 NWGSEL_RED_B[0]_28 Q_A_28 Q_B_28 RAM_A_28 RAM_B_28
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_96 SOB_98 SIA_108 SIB_110 TDA_28 TDB_28 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_28 WDATAO_B[0]_28 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_28 WENYB_28 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[4] CLK_DP_A CLK_DP_B DA_27 DB_27 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_27 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_27 NWGSEL_RED_B[0]_27 Q_A_27 Q_B_27 RAM_A_27 RAM_B_27
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_108 SIB_110 SOA_104 SOB_106 TDA_27 TDB_27 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_27 WDATAO_B[0]_27 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_27 WENYB_27 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[5] CLK_DP_A CLK_DP_B DA_26 DB_26 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_26 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_26 NWGSEL_RED_B[0]_26 Q_A_26 Q_B_26 RAM_A_26 RAM_B_26
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_104 SOB_106 SIA_116 SIB_118 TDA_26 TDB_26 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_26 WDATAO_B[0]_26 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_26 WENYB_26 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[6] CLK_DP_A CLK_DP_B DA_25 DB_25 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_25 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_25 NWGSEL_RED_B[0]_25 Q_A_25 Q_B_25 RAM_A_25 RAM_B_25
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_116 SIB_118 SOA_112 SOB_114 TDA_25 TDB_25 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_25 WDATAO_B[0]_25 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_25 WENYB_25 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[7] CLK_DP_A CLK_DP_B DA_24 DB_24 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_24 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_24 NWGSEL_RED_B[0]_24 Q_A_24 Q_B_24 RAM_A_24 RAM_B_24
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SOA_112 SOB_114 SIA_120 SIB_122 TDA_24 TDB_24 VPW
+  TWENA_LSHF TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW
+  VPW WDATAO_A[0]_24 WDATAO_B[0]_24 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_24 WENYB_24 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[8] CLK_DP_A CLK_DP_B DA_23 DB_23 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_23 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_23 NWGSEL_RED_B[0]_23 Q_A_23 Q_B_23 RAM_A_23 RAM_B_23
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_120 SIB_122 SIA_4 SIB_6 TDA_23 TDB_23 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_23 WDATAO_B[0]_23 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_23 WENYB_23 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
XDPTH[9] CLK_DP_A CLK_DP_B DA_22 DB_22 GTP_DWL TWENA_LSHF TWENB_LSHF WENA_LSHF
+  WENB_LSHF NC_VDDC_22 NDFTRAMBYP_A NDFTRAMBYP_B NTE_A NTE_B
+  NWGSEL_RED_A[0]_22 NWGSEL_RED_B[0]_22 Q_A_22 Q_B_22 RAM_A_22 RAM_B_22
+  SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_A SEL_D_B SEL_SI_A SEL_SI_B
+  SEL_TD_A SEL_TD_B SIA_4 SIB_6 SOA_0 SOB_2 TDA_22 TDB_22 VPW TWENA_LSHF
+  TWENA_LSHF VPW TWENB_LSHF TWENB_LSHF VDDCE VDDPE VDDPE VPW VPW VPW
+  WDATAO_A[0]_22 WDATAO_B[0]_22 VPW WENA_LSHF WENA_LSHF VPW WENB_LSHF
+  WENB_LSHF WENYA_22 WENYB_22 WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3]
+  WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] SRAMdpw64d256DPTH_RW_CM4
.ENDS SRAMdpw64d256DPTHSEC0_32O4R
****
.SUBCKT SRAMdpw64d256CNTL_NOTCH ACTCLMP BNK CADDR[0] CADDR[1] CADDR[2]
+  CADDR[3] CLK CLK_DP CLK_DP_A CLK_DP_B CLK_GTP DBL DFTRAMBYP DFTRAMBYP_BUF
+  EMAW[0] EMAW[1] EMA[0] EMA[1] EMA[2] GTP_DWL IOSEL[0] IOSEL[1] IOSEL_A[0]
+  IOSEL_A[1] IOSEL_B[0] IOSEL_B[1] ISCL_A ISCL_B ISCM_A ISCM_B LOG0 LOG0_DBL
+  LOG0_PG NBNK NCADDR[0] NCADDR[1] NCE NCLK_CTL NC_NDFTCRE NC_SE NC_SIG
+  NDFTRAMBYP NDFTRAMBYPT NDFTRAMBYP_A NDFTRAMBYP_B NGWE NGWE_WT NHDR_WL NRDT
+  NRET NRET_ACT_FT1 NRET_ACT_FT2 NTE NTE_A NTE_B NWR_MA NWTE NXPDEC1[0]
+  NXPDEC1[1] NXPDEC1[2] NXPDEC1[3] NXPDEC1[4] NXPDEC1[5] NXPDEC1[6]
+  NXPDEC1[7] NXPDEC2[0] NXPDEC2[1] NXPDEC2[2] NXPDEC2[3] NXPDEC2[4]
+  NXPDEC2[5] NXPDEC2[6] NXPDEC2[7] NXPDEC3[0] NXPDEC3[1] NXPDEC3[2]
+  NXPDEC3[3] RE RET SEL_D SEL_D_A SEL_D_B SEL_SI SEL_SI_A SEL_SI_B SEL_TD
+  SEL_TD_A SEL_TD_B SO_A SO_B STUB_PEN_CG STUB_TPEN TWEN_A TWEN_B VDDCE VDDPE
+  VNWC VNWP VPW VSS VSSE WE WEN_A WEN_B WGSEL[0] WGSEL[1] WGSEL[2] WGSEL[3]
+  WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1]
+  WGSEL_B[2] WGSEL_B[3] WR_MA WTE
** SRAMdpw64d256CNTL_NOTCH: 390 flat devices **
X_MI119.I0.MXNA1 I119.NET15 I119.GWE I119.I0.N1 VPW N11LL_CKT W=1.135U L=0.04U
X_MI119.I0.MXNA2 I119.I0.N1 I119.NDFTRAMBYP VSS VPW N11LL_CKT W=1.135U L=0.04U
X_MI119.I0.MXPA1 I119.NET15 I119.GWE VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI119.I0.MXPA2 I119.NET15 I119.NDFTRAMBYP VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI119.I11.MXNA1 I119.NET23 NGWE I119.I11.N1 VPW N11LL_CKT W=1.135U L=0.04U
X_MI119.I11.MXNA2 I119.I11.N1 I119.NDFTRAMBYP VSS VPW N11LL_CKT W=1.135U
+  L=0.04U
X_MI119.I11.MXPA1 I119.NET23 NGWE VDDPE VNWP P11LL_CKT W=1.135U L=0.04U
X_MI119.I11.MXPA2 I119.NET23 I119.NDFTRAMBYP VDDPE VNWP P11LL_CKT W=1.135U
+  L=0.04U
X_MI119.I12.MXNA1 RE I119.NET23 VSS VPW N11LL_CKT W=2.26U L=0.04U
X_MI119.I12.MXPA1 RE I119.NET23 VDDPE VNWP P11LL_CKT W=4.54U L=0.04U
X_MI119.I13.MXNA1 I119.NDFTRAMBYP DFTRAMBYP VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI119.I13.MXPA1 I119.NDFTRAMBYP DFTRAMBYP VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MI119.I14.MXNA1 WE I119.NET15 VSS VPW N11LL_CKT W=2.26U L=0.04U
X_MI119.I14.MXPA1 WE I119.NET15 VDDPE VNWP P11LL_CKT W=4.54U L=0.04U
X_MI119.I15.MXNA1 I119.GWE NGWE VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MI119.I15.MXPA1 I119.GWE NGWE VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MI121.MXNA1 GWE NGWE VSS VPW N11LL_CKT W=0.14U L=0.04U
X_MI121.MXPA1 GWE NGWE VDDPE VNWP P11LL_CKT W=0.215U L=0.04U
X_MI126.MXNA1 NDFTRAMBYPT DFTRAMBYP VSS VPW N11LL_CKT W=1.7U L=0.04U
X_MI126.MXPA1 NDFTRAMBYPT DFTRAMBYP VDDPE VNWP P11LL_CKT W=3.4U L=0.04U
X_MI44.MXNA1 NDFTRAMBYP DFTRAMBYP_BUF VSS VPW N11LL_CKT W=4.26U L=0.04U
X_MI44.MXPA1 NDFTRAMBYP DFTRAMBYP_BUF VDDPE VNWP P11LL_CKT W=8.505U L=0.04U
X_MI60.I60.MXN0 LOG0 I60.I60.NODEB VSSE VPW N11LL_CKT W=0.71U L=0.04U
X_MI60.I60.MXN1 I60.I60.NODEA I60.I60.NODEA VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI60.I60.MXN2 I60.I60.NODEA I60.I60.NODEB VSSE VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MI60.I60.MXP1 I60.I60.NODEB I60.I60.NODEA VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MI60.I60.MXP4 LOG1 I60.I60.NODEA VDDPE VNWP P11LL_CKT W=0.14U L=0.04U
X_MIInvlb_0.I2.MXNA1 CADDR[1] NCADDR[1] VSS VPW N11LL_CKT W=2.35U L=0.04U
X_MIInvlb_0.I2.MXPA1 CADDR[1] NCADDR[1] VDDPE VNWP P11LL_CKT W=4.525U L=0.04U
X_MIInvlb_1.I2.MXNA1 BNK NBNK VSS VPW N11LL_CKT W=2.35U L=0.04U
X_MIInvlb_1.I2.MXPA1 BNK NBNK VDDPE VNWP P11LL_CKT W=4.525U L=0.04U
X_MIInvlb_2.I2.MXNA1 WTE NWTE VSS VPW N11LL_CKT W=2.35U L=0.04U
X_MIInvlb_2.I2.MXPA1 WTE NWTE VDDPE VNWP P11LL_CKT W=4.525U L=0.04U
X_MIcaddr.I1.MXNA1 ICADDR.NCLK NCLK_CTL VSS VPW N11LL_CKT W=0.285U L=0.04U
X_MIcaddr.I1.MXPA1 ICADDR.NCLK NCLK_CTL VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIcaddr.I5_0.MXNA1 ICADDR.ADDR_PL_N[2] CADDR[2] VSS VPW N11LL_CKT W=0.595U
+  L=0.04U
X_MIcaddr.I5_0.MXPA1 ICADDR.ADDR_PL_N[2] CADDR[2] VDDPE VNWP P11LL_CKT
+  W=0.895U L=0.04U
X_MIcaddr.I5_1.MXNA1 ICADDR.ADDR_PL_N[3] CADDR[3] VSS VPW N11LL_CKT W=0.595U
+  L=0.04U
X_MIcaddr.I5_1.MXPA1 ICADDR.ADDR_PL_N[3] CADDR[3] VDDPE VNWP P11LL_CKT
+  W=0.895U L=0.04U
X_MIcaddr.I6_0.MXNA1 ICADDR.WGSEL_N[0] ICADDR.ADDR_PL_N[3] ICADDR.I6_0.N1 VPW
+  N11LL_CKT W=1.195U L=0.04U
X_MIcaddr.I6_0.MXNA2 ICADDR.I6_0.N1 ICADDR.ADDR_PL_N[2] VSS VPW N11LL_CKT
+  W=1.195U L=0.04U
X_MIcaddr.I6_0.MXPA1 ICADDR.WGSEL_N[0] ICADDR.ADDR_PL_N[3] VDDPE VNWP
+  P11LL_CKT W=1.195U L=0.04U
X_MIcaddr.I6_0.MXPA2 ICADDR.WGSEL_N[0] ICADDR.ADDR_PL_N[2] VDDPE VNWP
+  P11LL_CKT W=1.195U L=0.04U
X_MIcaddr.I6_1.MXNA1 ICADDR.WGSEL_N[1] ICADDR.ADDR_PL_N[3] ICADDR.I6_1.N1 VPW
+  N11LL_CKT W=1.195U L=0.04U
X_MIcaddr.I6_1.MXNA2 ICADDR.I6_1.N1 CADDR[2] VSS VPW N11LL_CKT W=1.195U
+  L=0.04U
X_MIcaddr.I6_1.MXPA1 ICADDR.WGSEL_N[1] ICADDR.ADDR_PL_N[3] VDDPE VNWP
+  P11LL_CKT W=1.195U L=0.04U
X_MIcaddr.I6_1.MXPA2 ICADDR.WGSEL_N[1] CADDR[2] VDDPE VNWP P11LL_CKT W=1.195U
+  L=0.04U
X_MIcaddr.I6_2.MXNA1 ICADDR.WGSEL_N[2] CADDR[3] ICADDR.I6_2.N1 VPW N11LL_CKT
+  W=1.195U L=0.04U
X_MIcaddr.I6_2.MXNA2 ICADDR.I6_2.N1 ICADDR.ADDR_PL_N[2] VSS VPW N11LL_CKT
+  W=1.195U L=0.04U
X_MIcaddr.I6_2.MXPA1 ICADDR.WGSEL_N[2] CADDR[3] VDDPE VNWP P11LL_CKT W=1.195U
+  L=0.04U
X_MIcaddr.I6_2.MXPA2 ICADDR.WGSEL_N[2] ICADDR.ADDR_PL_N[2] VDDPE VNWP
+  P11LL_CKT W=1.195U L=0.04U
X_MIcaddr.I6_3.MXNA1 ICADDR.WGSEL_N[3] CADDR[3] ICADDR.I6_3.N1 VPW N11LL_CKT
+  W=1.195U L=0.04U
X_MIcaddr.I6_3.MXNA2 ICADDR.I6_3.N1 CADDR[2] VSS VPW N11LL_CKT W=1.195U
+  L=0.04U
X_MIcaddr.I6_3.MXPA1 ICADDR.WGSEL_N[3] CADDR[3] VDDPE VNWP P11LL_CKT W=1.195U
+  L=0.04U
X_MIcaddr.I6_3.MXPA2 ICADDR.WGSEL_N[3] CADDR[2] VDDPE VNWP P11LL_CKT W=1.195U
+  L=0.04U
X_MIcaddr.I7_0.MXNA1 WGSEL[0] ICADDR.WGSEL_N[0] VSS VPW N11LL_CKT W=3.33U
+  L=0.04U
X_MIcaddr.I7_0.MXPA1 WGSEL[0] ICADDR.WGSEL_N[0] VDDPE VNWP P11LL_CKT W=5U
+  L=0.04U
X_MIcaddr.I7_1.MXNA1 WGSEL[1] ICADDR.WGSEL_N[1] VSS VPW N11LL_CKT W=3.33U
+  L=0.04U
X_MIcaddr.I7_1.MXPA1 WGSEL[1] ICADDR.WGSEL_N[1] VDDPE VNWP P11LL_CKT W=5U
+  L=0.04U
X_MIcaddr.I7_2.MXNA1 WGSEL[2] ICADDR.WGSEL_N[2] VSS VPW N11LL_CKT W=3.33U
+  L=0.04U
X_MIcaddr.I7_2.MXPA1 WGSEL[2] ICADDR.WGSEL_N[2] VDDPE VNWP P11LL_CKT W=5U
+  L=0.04U
X_MIcaddr.I7_3.MXNA1 WGSEL[3] ICADDR.WGSEL_N[3] VSS VPW N11LL_CKT W=3.33U
+  L=0.04U
X_MIcaddr.I7_3.MXPA1 WGSEL[3] ICADDR.WGSEL_N[3] VDDPE VNWP P11LL_CKT W=5U
+  L=0.04U
X_MIcaddr.Ilat_0.I12.MXNA1 ICADDR.ILAT_0.BCLK ICADDR.ILAT_0.NCLK VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIcaddr.Ilat_0.I12.MXPA1 ICADDR.ILAT_0.BCLK ICADDR.ILAT_0.NCLK VDDPE VNWP
+  P11LL_CKT W=0.31U L=0.04U
X_MIcaddr.Ilat_0.I14.I47.MXNA1 ICADDR.ILAT_0.I14.ND CADDR[2] VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_MIcaddr.Ilat_0.I14.I47.MXPA1 ICADDR.ILAT_0.I14.ND CADDR[2] VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_MIcaddr.Ilat_0.I14.I48.MXNOE ICADDR.ILAT_0.NET25 ICADDR.ILAT_0.BCLK
+  ICADDR.ILAT_0.I14.ND VPW N11LL_CKT W=0.34U L=0.04U
X_MIcaddr.Ilat_0.I14.I48.MXPOEN ICADDR.ILAT_0.NET25 ICADDR.ILAT_0.NCLK
+  ICADDR.ILAT_0.I14.ND VNWP P11LL_CKT W=0.34U L=0.04U
X_MIcaddr.Ilat_0.I14.I50.MXNA1 ICADDR.ILAT_0.NET33 ICADDR.ILAT_0.NET25 VSS VPW
+  N11LL_CKT W=0.45U L=0.04U
X_MIcaddr.Ilat_0.I14.I50.MXPA1 ICADDR.ILAT_0.NET33 ICADDR.ILAT_0.NET25 VDDPE
+  VNWP P11LL_CKT W=0.62U L=0.04U
X_MIcaddr.Ilat_0.I14.I55.MXNA1 ICADDR.ILAT_0.I14.I55.N1 ICADDR.ILAT_0.NET33
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_0.I14.I55.MXNOE ICADDR.ILAT_0.NET25 ICADDR.ILAT_0.NCLK
+  ICADDR.ILAT_0.I14.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_0.I14.I55.MXPA1 ICADDR.ILAT_0.I14.I55.P1 ICADDR.ILAT_0.NET33
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_0.I14.I55.MXPOEN ICADDR.ILAT_0.NET25 ICADDR.ILAT_0.BCLK
+  ICADDR.ILAT_0.I14.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_0.I21.MXNA1 ICADDR.ILAT_0.NCLK ICADDR.NCLK ICADDR.ILAT_0.I21.N1
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIcaddr.Ilat_0.I21.MXNA2 ICADDR.ILAT_0.I21.N1 NGWE_WT VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcaddr.Ilat_0.I21.MXPA1 ICADDR.ILAT_0.NCLK ICADDR.NCLK VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcaddr.Ilat_0.I21.MXPA2 ICADDR.ILAT_0.NCLK NGWE_WT VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcaddr.Ilat_0.I6.MXNA1 ICADDR.ILAT_0.Q_N ICADDR.ILAT_0.NET33 VSS VPW
+  N11LL_CKT W=1.11U L=0.04U
X_MIcaddr.Ilat_0.I6.MXPA1 ICADDR.ILAT_0.Q_N ICADDR.ILAT_0.NET33 VDDPE VNWP
+  P11LL_CKT W=2.23U L=0.04U
X_MIcaddr.Ilat_0.I7.MXNA1 IOSEL[0] ICADDR.ILAT_0.Q_N VSS VPW N11LL_CKT
+  W=4.455U L=0.04U
X_MIcaddr.Ilat_0.I7.MXPA1 IOSEL[0] ICADDR.ILAT_0.Q_N VDDPE VNWP P11LL_CKT
+  W=8.955U L=0.04U
X_MIcaddr.Ilat_1.I12.MXNA1 ICADDR.ILAT_1.BCLK ICADDR.ILAT_1.NCLK VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIcaddr.Ilat_1.I12.MXPA1 ICADDR.ILAT_1.BCLK ICADDR.ILAT_1.NCLK VDDPE VNWP
+  P11LL_CKT W=0.31U L=0.04U
X_MIcaddr.Ilat_1.I14.I47.MXNA1 ICADDR.ILAT_1.I14.ND CADDR[3] VSS VPW N11LL_CKT
+  W=0.34U L=0.04U
X_MIcaddr.Ilat_1.I14.I47.MXPA1 ICADDR.ILAT_1.I14.ND CADDR[3] VDDPE VNWP
+  P11LL_CKT W=0.51U L=0.04U
X_MIcaddr.Ilat_1.I14.I48.MXNOE ICADDR.ILAT_1.NET25 ICADDR.ILAT_1.BCLK
+  ICADDR.ILAT_1.I14.ND VPW N11LL_CKT W=0.34U L=0.04U
X_MIcaddr.Ilat_1.I14.I48.MXPOEN ICADDR.ILAT_1.NET25 ICADDR.ILAT_1.NCLK
+  ICADDR.ILAT_1.I14.ND VNWP P11LL_CKT W=0.34U L=0.04U
X_MIcaddr.Ilat_1.I14.I50.MXNA1 ICADDR.ILAT_1.NET33 ICADDR.ILAT_1.NET25 VSS VPW
+  N11LL_CKT W=0.45U L=0.04U
X_MIcaddr.Ilat_1.I14.I50.MXPA1 ICADDR.ILAT_1.NET33 ICADDR.ILAT_1.NET25 VDDPE
+  VNWP P11LL_CKT W=0.62U L=0.04U
X_MIcaddr.Ilat_1.I14.I55.MXNA1 ICADDR.ILAT_1.I14.I55.N1 ICADDR.ILAT_1.NET33
+  VSS VPW N11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_1.I14.I55.MXNOE ICADDR.ILAT_1.NET25 ICADDR.ILAT_1.NCLK
+  ICADDR.ILAT_1.I14.I55.N1 VPW N11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_1.I14.I55.MXPA1 ICADDR.ILAT_1.I14.I55.P1 ICADDR.ILAT_1.NET33
+  VDDPE VNWP P11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_1.I14.I55.MXPOEN ICADDR.ILAT_1.NET25 ICADDR.ILAT_1.BCLK
+  ICADDR.ILAT_1.I14.I55.P1 VNWP P11LL_CKT W=0.15U L=0.04U
X_MIcaddr.Ilat_1.I21.MXNA1 ICADDR.ILAT_1.NCLK ICADDR.NCLK ICADDR.ILAT_1.I21.N1
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIcaddr.Ilat_1.I21.MXNA2 ICADDR.ILAT_1.I21.N1 NGWE_WT VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcaddr.Ilat_1.I21.MXPA1 ICADDR.ILAT_1.NCLK ICADDR.NCLK VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcaddr.Ilat_1.I21.MXPA2 ICADDR.ILAT_1.NCLK NGWE_WT VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcaddr.Ilat_1.I6.MXNA1 ICADDR.ILAT_1.Q_N ICADDR.ILAT_1.NET33 VSS VPW
+  N11LL_CKT W=1.11U L=0.04U
X_MIcaddr.Ilat_1.I6.MXPA1 ICADDR.ILAT_1.Q_N ICADDR.ILAT_1.NET33 VDDPE VNWP
+  P11LL_CKT W=2.23U L=0.04U
X_MIcaddr.Ilat_1.I7.MXNA1 IOSEL[1] ICADDR.ILAT_1.Q_N VSS VPW N11LL_CKT
+  W=4.455U L=0.04U
X_MIcaddr.Ilat_1.I7.MXPA1 IOSEL[1] ICADDR.ILAT_1.Q_N VDDPE VNWP P11LL_CKT
+  W=8.955U L=0.04U
X_MIclkgen.Iagtp.I89.MXNA1 NCLK_CTL ICLKGEN.IAGTP.AGTP_CTL VSS VPW N11LL_CKT
+  W=3.96U L=0.04U
X_MIclkgen.Iagtp.I89.MXPA1 NCLK_CTL ICLKGEN.IAGTP.AGTP_CTL VDDPE VNWP
+  P11LL_CKT W=5.97U L=0.04U
X_MIclkgen.Iagtp.MXN0 ICLKGEN.IAGTP.NET054 ICLKGEN.IAGTP.DI1 VSS VPW N11LL_CKT
+  W=0.2U L=0.04U
X_MIclkgen.Iagtp.MXN1 ICLKGEN.IAGTP.AGTPD NGTP ICLKGEN.IAGTP.NET054 VPW
+  N11LL_CKT W=0.2U L=0.04U
X_MIclkgen.Iagtp.MXN10 CLK_DP ICLKGEN.IAGTP.NET27 VSS VPW N11LL_CKT W=5U
+  L=0.04U
X_MIclkgen.Iagtp.MXN14 ICLKGEN.IAGTP.NDI3 ICLKGEN.IAGTP.DI1
+  ICLKGEN.IAGTP.NET0132 VPW N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN15 ICLKGEN.IAGTP.NET0132 ICLKGEN.IAGTP.DI1 VSS VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN16 ICLKGEN.IAGTP.DI3 ICLKGEN.IAGTP.NDI3 VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN17 ICLKGEN.IAGTP.AGTP_CTL NGTP ICLKGEN.IAGTP.NET0148 VPW
+  N11LL_CKT W=0.75U L=0.04U
X_MIclkgen.Iagtp.MXN18 ICLKGEN.IAGTP.NET0148 ICLKGEN.IAGTP.DI1 VSS VPW
+  N11LL_CKT W=0.75U L=0.04U
X_MIclkgen.Iagtp.MXN2 ICLKGEN.IAGTP.NET081 ICLKGEN.IAGTP.DI VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN3 ICLKGEN.IAGTP.NET045 ICLKGEN.NFEED VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN4 ICLKGEN.IAGTP.DI ICLKGEN.IAGTP.NDI VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN5 ICLKGEN.IAGTP.DI1 ICLKGEN.IAGTP.NDI1 VSS VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN6 ICLKGEN.IAGTP.NDI1 ICLKGEN.IAGTP.DI ICLKGEN.IAGTP.NET081
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXN7 ICLKGEN.IAGTP.NET27 ICLKGEN.IAGTP.AGTPD VSS VPW
+  N11LL_CKT W=1.49U L=0.04U
X_MIclkgen.Iagtp.MXN8 ICLKGEN.IAGTP.NDI ICLKGEN.NFEED ICLKGEN.IAGTP.NET045 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP0 ICLKGEN.IAGTP.NDI ICLKGEN.NFEED VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIclkgen.Iagtp.MXP1 ICLKGEN.IAGTP.DI ICLKGEN.IAGTP.NDI ICLKGEN.IAGTP.NET024
+  VNWP P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP13 ICLKGEN.IAGTP.NDI3 ICLKGEN.IAGTP.DI1 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP14 ICLKGEN.IAGTP.DI3 ICLKGEN.IAGTP.NDI3
+  ICLKGEN.IAGTP.NET067 VNWP P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP15 ICLKGEN.IAGTP.NET067 ICLKGEN.IAGTP.NDI3 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP16 ICLKGEN.IAGTP.AGTP_CTL NGTP VDDPE VNWP P11LL_CKT
+  W=1.84U L=0.04U
X_MIclkgen.Iagtp.MXP17 ICLKGEN.IAGTP.AGTP_CTL ICLKGEN.IAGTP.DI1 VDDPE VNWP
+  P11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iagtp.MXP2 ICLKGEN.IAGTP.NET024 ICLKGEN.IAGTP.NDI VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP3 ICLKGEN.IAGTP.AGTPD NGTP VDDPE VNWP P11LL_CKT W=0.995U
+  L=0.04U
X_MIclkgen.Iagtp.MXP4 ICLKGEN.IAGTP.AGTPD ICLKGEN.IAGTP.DI1 VDDPE VNWP
+  P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iagtp.MXP6 ICLKGEN.IAGTP.NDI1 ICLKGEN.IAGTP.DI VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iagtp.MXP7 ICLKGEN.IAGTP.DI1 ICLKGEN.IAGTP.NDI1 VDDPE VNWP
+  P11LL_CKT W=0.345U L=0.04U
X_MIclkgen.Iagtp.MXP8 ICLKGEN.IAGTP.NET27 ICLKGEN.IAGTP.AGTPD VDDPE VNWP
+  P11LL_CKT W=1.99U L=0.04U
X_MIclkgen.Iagtp.MXP9 CLK_DP ICLKGEN.IAGTP.NET27 VDDPE VNWP P11LL_CKT W=13.5U
+  L=0.04U
X_MIclkgen.Iema.I1.MXNA1 ICLKGEN.IEMA.NRDLY GTP_SA VSSE VPW N11LL_CKT W=0.8U
+  L=0.04U
X_MIclkgen.Iema.I1.MXPA1 ICLKGEN.IEMA.NRDLY GTP_SA VDDPE VNWP P11LL_CKT W=1.2U
+  L=0.04U
X_MIclkgen.Iema.I2.MXNA1 ICLKGEN.IEMA.NWDLY ICLKGEN.IEMA.WDLY VSSE VPW
+  N11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iema.I2.MXPA1 ICLKGEN.IEMA.NWDLY ICLKGEN.IEMA.WDLY VDDPE VNWP
+  P11LL_CKT W=1.28U L=0.04U
X_MIclkgen.Iema.I20.MXNOE ICLKGEN.RESET ICLKGEN.IEMA.NGWE ICLKGEN.IEMA.NRDLY
+  VPW N11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iema.I20.MXPOEN ICLKGEN.RESET ICLKGEN.IEMA.IGWE ICLKGEN.IEMA.NRDLY
+  VNWP P11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iema.I21.MXNOE ICLKGEN.RESET ICLKGEN.IEMA.IGWE ICLKGEN.IEMA.NWDLY
+  VPW N11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iema.I21.MXPOEN ICLKGEN.RESET ICLKGEN.IEMA.NGWE ICLKGEN.IEMA.NWDLY
+  VNWP P11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iema.I24.MXNA1 ICLKGEN.IEMA.WCLK10 ICLKGEN.IEMA.NRCLK VSSE VPW
+  N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.I24.MXPA1 ICLKGEN.IEMA.WCLK10 ICLKGEN.IEMA.NRCLK VDDPE VNWP
+  P11LL_CKT W=1.14U L=0.04U
X_MIclkgen.Iema.I27.MXNA1 ICLKGEN.IEMA.NRCLK GTP_SA VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iema.I27.MXPA1 ICLKGEN.IEMA.NRCLK GTP_SA VDDPE VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIclkgen.Iema.I30.MXNA1 ICLKGEN.IEMA.WEMA01 ICLKGEN.IEMA.NWEMA01 VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.I30.MXPA1 ICLKGEN.IEMA.WEMA01 ICLKGEN.IEMA.NWEMA01 VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.I40.MXNA1 ICLKGEN.IEMA.IGWE ICLKGEN.IEMA.NGWE VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.I40.MXPA1 ICLKGEN.IEMA.IGWE ICLKGEN.IEMA.NGWE VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux.I61.MXNA1 ICLKGEN.IEMA.NCK_IN SAE_DUMMY VSSE VPW
+  N11LL_CKT W=1.02U L=0.04U
X_MIclkgen.Iema.Irmux.I61.MXPA1 ICLKGEN.IEMA.NCK_IN SAE_DUMMY VDDPE VNWP
+  P11LL_CKT W=1.535U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXN3 ICLKGEN.IEMA.IRMUX._RDLY0.NET40
+  ICLKGEN.IEMA.IRMUX.CKMX1O ICLKGEN.IEMA.IRMUX._RDLY0.NET045 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXN4 ICLKGEN.IEMA.IRMUX.CKDLY0
+  ICLKGEN.IEMA.IRMUX._RDLY0.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXN8 ICLKGEN.IEMA.IRMUX._RDLY0.NDIN
+  ICLKGEN.IEMA.IRMUX.CKMX1O ICLKGEN.IEMA.IRMUX._RDLY0.NET40 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXN9 ICLKGEN.IEMA.IRMUX._RDLY0.NET045
+  ICLKGEN.IEMA.IRMUX.CKMX1O VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXP0 ICLKGEN.IEMA.IRMUX._RDLY0.NDIN
+  ICLKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXP2 ICLKGEN.IEMA.IRMUX._RDLY0.NET030
+  ICLKGEN.IEMA.IRMUX._RDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly0.MXP4 ICLKGEN.IEMA.IRMUX.CKDLY0
+  ICLKGEN.IEMA.IRMUX._RDLY0.NDIN ICLKGEN.IEMA.IRMUX._RDLY0.NET030 VNWP
+  P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXN3 ICLKGEN.IEMA.IRMUX._RDLY1.NET046
+  ICLKGEN.IEMA.IRMUX.CKDLY2 ICLKGEN.IEMA.IRMUX._RDLY1.NET038 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXN4 ICLKGEN.IEMA.IRMUX.CKDLY1
+  ICLKGEN.IEMA.IRMUX._RDLY1.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXN8 ICLKGEN.IEMA.IRMUX._RDLY1.NDIN
+  ICLKGEN.IEMA.IRMUX.CKDLY2 ICLKGEN.IEMA.IRMUX._RDLY1.NET046 VPW N11LL_CKT
+  W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXN9 ICLKGEN.IEMA.IRMUX._RDLY1.NET038
+  ICLKGEN.IEMA.IRMUX.CKDLY2 VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXP0 ICLKGEN.IEMA.IRMUX._RDLY1.NDIN
+  ICLKGEN.IEMA.IRMUX.CKDLY2 VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXP2 ICLKGEN.IEMA.IRMUX._RDLY1.NET030
+  ICLKGEN.IEMA.IRMUX._RDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Irmux._rdly1.MXP4 ICLKGEN.IEMA.IRMUX.CKDLY1
+  ICLKGEN.IEMA.IRMUX._RDLY1.NDIN ICLKGEN.IEMA.IRMUX._RDLY1.NET030 VNWP
+  P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXN3 ICLKGEN.IEMA.IRMUX._RDLY2.NET046 SAE_DUMMY
+  ICLKGEN.IEMA.IRMUX._RDLY2.NET038 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXN4 ICLKGEN.IEMA.IRMUX.CKDLY2
+  ICLKGEN.IEMA.IRMUX._RDLY2.NDIN VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXN8 ICLKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY
+  ICLKGEN.IEMA.IRMUX._RDLY2.NET046 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXN9 ICLKGEN.IEMA.IRMUX._RDLY2.NET038 SAE_DUMMY
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXP0 ICLKGEN.IEMA.IRMUX._RDLY2.NDIN SAE_DUMMY
+  VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXP2 ICLKGEN.IEMA.IRMUX._RDLY2.NET030
+  ICLKGEN.IEMA.IRMUX._RDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Irmux._rdly2.MXP4 ICLKGEN.IEMA.IRMUX.CKDLY2
+  ICLKGEN.IEMA.IRMUX._RDLY2.NDIN ICLKGEN.IEMA.IRMUX._RDLY2.NET030 VNWP
+  P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I12.MXNA1 ICLKGEN.IEMA.IRMUX._RMX0.A0
+  ICLKGEN.IEMA.IRMUX.CKMX1O ICLKGEN.IEMA.IRMUX._RMX0.I12.N1 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I12.MXNA2 ICLKGEN.IEMA.IRMUX._RMX0.I12.N1
+  ICLKGEN.IEMA.IRMUX._RMX0.SEL_IN VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I12.MXPA1 ICLKGEN.IEMA.IRMUX._RMX0.A0
+  ICLKGEN.IEMA.IRMUX.CKMX1O VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I12.MXPA2 ICLKGEN.IEMA.IRMUX._RMX0.A0
+  ICLKGEN.IEMA.IRMUX._RMX0.SEL_IN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I13.MXNA1 ICLKGEN.IEMA.IRMUX._RMX0.A1
+  ICLKGEN.IEMA.IRMUX.CKDLY0 ICLKGEN.IEMA.IRMUX._RMX0.I13.N1 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I13.MXNA2 ICLKGEN.IEMA.IRMUX._RMX0.I13.N1 EMA[0]
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I13.MXPA1 ICLKGEN.IEMA.IRMUX._RMX0.A1
+  ICLKGEN.IEMA.IRMUX.CKDLY0 VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I13.MXPA2 ICLKGEN.IEMA.IRMUX._RMX0.A1 EMA[0] VDDPE
+  VNWP P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I18.MXN0 ICLKGEN.IEMA.IRMUX.NET67
+  ICLKGEN.IEMA.IRMUX._RMX0.A0 ICLKGEN.IEMA.IRMUX._RMX0.I18.A1A2 VPW N11LL_CKT
+  W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I18.MXN1 ICLKGEN.IEMA.IRMUX.NET67
+  ICLKGEN.IEMA.NCK_IN VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I18.MXN3 ICLKGEN.IEMA.IRMUX._RMX0.I18.A1A2
+  ICLKGEN.IEMA.IRMUX._RMX0.A1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I18.MXP0 ICLKGEN.IEMA.IRMUX.NET67
+  ICLKGEN.IEMA.IRMUX._RMX0.A0 ICLKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I18.MXP1 ICLKGEN.IEMA.IRMUX.NET67
+  ICLKGEN.IEMA.IRMUX._RMX0.A1 ICLKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP VNWP
+  P11LL_CKT W=0.71U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I18.MXP2 ICLKGEN.IEMA.IRMUX._RMX0.I18.A1A2UP
+  ICLKGEN.IEMA.NCK_IN VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I2.MXNA1 ICLKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0]
+  VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_MIclkgen.Iema.Irmux._rmx0.I2.MXPA1 ICLKGEN.IEMA.IRMUX._RMX0.SEL_IN EMA[0]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I19.MXNA1 ICLKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I19.MXPA1 ICLKGEN.IEMA.IRMUX._RMX00.NCK_IN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I2.MXNA1 ICLKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I2.MXPA1 ICLKGEN.IEMA.IRMUX._RMX00.SEL_IN EMA[2]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I20.MXNA1 ICLKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  ICLKGEN.IEMA.IRMUX.NET67 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I20.MXPA1 ICLKGEN.IEMA.IRMUX._RMX00.NCK_DLY
+  ICLKGEN.IEMA.IRMUX.NET67 VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I21.MXNOE ICLKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  ICLKGEN.IEMA.IRMUX._RMX00.SEL_IN ICLKGEN.IEMA.IRMUX._RMX00.NCK_IN VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I21.MXPOEN ICLKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  EMA[2] ICLKGEN.IEMA.IRMUX._RMX00.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I22.MXNOE ICLKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  EMA[2] ICLKGEN.IEMA.IRMUX._RMX00.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I22.MXPOEN ICLKGEN.IEMA.IRMUX._RMX00.NCK_OUT
+  ICLKGEN.IEMA.IRMUX._RMX00.SEL_IN ICLKGEN.IEMA.IRMUX._RMX00.NCK_DLY VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I23.MXNA1 GTP_SA
+  ICLKGEN.IEMA.IRMUX._RMX00.NCK_OUT VSSE VPW N11LL_CKT W=0.85U L=0.04U
X_MIclkgen.Iema.Irmux._rmx00.I23.MXPA1 GTP_SA
+  ICLKGEN.IEMA.IRMUX._RMX00.NCK_OUT VDDPE VNWP P11LL_CKT W=1.42U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I19.MXNA1 ICLKGEN.IEMA.IRMUX._RMX1.NCK_IN
+  SAE_DUMMY VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I19.MXPA1 ICLKGEN.IEMA.IRMUX._RMX1.NCK_IN
+  SAE_DUMMY VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I2.MXNA1 ICLKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1]
+  VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I2.MXPA1 ICLKGEN.IEMA.IRMUX._RMX1.SEL_IN EMA[1]
+  VDDPE VNWP P11LL_CKT W=0.17U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I20.MXNA1 ICLKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  ICLKGEN.IEMA.IRMUX.CKDLY1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I20.MXPA1 ICLKGEN.IEMA.IRMUX._RMX1.NCK_DLY
+  ICLKGEN.IEMA.IRMUX.CKDLY1 VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I21.MXNOE ICLKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  ICLKGEN.IEMA.IRMUX._RMX1.SEL_IN ICLKGEN.IEMA.IRMUX._RMX1.NCK_IN VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I21.MXPOEN ICLKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  ICLKGEN.IEMA.IRMUX._RMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I22.MXNOE ICLKGEN.IEMA.IRMUX._RMX1.NCK_OUT EMA[1]
+  ICLKGEN.IEMA.IRMUX._RMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I22.MXPOEN ICLKGEN.IEMA.IRMUX._RMX1.NCK_OUT
+  ICLKGEN.IEMA.IRMUX._RMX1.SEL_IN ICLKGEN.IEMA.IRMUX._RMX1.NCK_DLY VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I23.MXNA1 ICLKGEN.IEMA.IRMUX.CKMX1O
+  ICLKGEN.IEMA.IRMUX._RMX1.NCK_OUT VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Irmux._rmx1.I23.MXPA1 ICLKGEN.IEMA.IRMUX.CKMX1O
+  ICLKGEN.IEMA.IRMUX._RMX1.NCK_OUT VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXN3 ICLKGEN.IEMA.IWDLY0.NET057 ICLKGEN.IEMA.WCLK00
+  ICLKGEN.IEMA.IWDLY0.NET049 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXN4 ICLKGEN.IEMA.WCLK01 ICLKGEN.IEMA.IWDLY0.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXN8 ICLKGEN.IEMA.IWDLY0.NDIN ICLKGEN.IEMA.WCLK00
+  ICLKGEN.IEMA.IWDLY0.NET057 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXN9 ICLKGEN.IEMA.IWDLY0.NET049 ICLKGEN.IEMA.WCLK00
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXP0 ICLKGEN.IEMA.IWDLY0.NDIN ICLKGEN.IEMA.WCLK00 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXP1 ICLKGEN.IEMA.WCLK01 ICLKGEN.IEMA.IWDLY0.NDIN
+  ICLKGEN.IEMA.IWDLY0.NET044 VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Iwdly0.MXP2 ICLKGEN.IEMA.IWDLY0.NET044
+  ICLKGEN.IEMA.IWDLY0.NDIN VDDPE VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXN3 ICLKGEN.IEMA.IWDLY1.NET057 ICLKGEN.IEMA.DWCLK10
+  ICLKGEN.IEMA.IWDLY1.NET049 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXN4 ICLKGEN.IEMA.WCLK11 ICLKGEN.IEMA.IWDLY1.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXN8 ICLKGEN.IEMA.IWDLY1.NDIN ICLKGEN.IEMA.DWCLK10
+  ICLKGEN.IEMA.IWDLY1.NET057 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXN9 ICLKGEN.IEMA.IWDLY1.NET049 ICLKGEN.IEMA.DWCLK10
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXP0 ICLKGEN.IEMA.IWDLY1.NDIN ICLKGEN.IEMA.DWCLK10
+  VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXP1 ICLKGEN.IEMA.WCLK11 ICLKGEN.IEMA.IWDLY1.NDIN
+  ICLKGEN.IEMA.IWDLY1.NET044 VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Iwdly1.MXP2 ICLKGEN.IEMA.IWDLY1.NET044
+  ICLKGEN.IEMA.IWDLY1.NDIN VDDPE VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXN3 ICLKGEN.IEMA.IWDLY2.NET057 ICLKGEN.IEMA.WCLK10
+  ICLKGEN.IEMA.IWDLY2.NET049 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXN4 ICLKGEN.IEMA.DWCLK10 ICLKGEN.IEMA.IWDLY2.NDIN VSSE
+  VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXN8 ICLKGEN.IEMA.IWDLY2.NDIN ICLKGEN.IEMA.WCLK10
+  ICLKGEN.IEMA.IWDLY2.NET057 VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXN9 ICLKGEN.IEMA.IWDLY2.NET049 ICLKGEN.IEMA.WCLK10
+  VSSE VPW N11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXP0 ICLKGEN.IEMA.IWDLY2.NDIN ICLKGEN.IEMA.WCLK10 VDDPE
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXP1 ICLKGEN.IEMA.DWCLK10 ICLKGEN.IEMA.IWDLY2.NDIN
+  ICLKGEN.IEMA.IWDLY2.NET044 VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Iwdly2.MXP2 ICLKGEN.IEMA.IWDLY2.NET044
+  ICLKGEN.IEMA.IWDLY2.NDIN VDDPE VNWP P11LL_CKT W=0.765U L=0.04U
X_MIclkgen.Iema.Iwmx0.I12.MXNA1 ICLKGEN.IEMA.IWMX0.A0 ICLKGEN.IEMA.WCLK00
+  ICLKGEN.IEMA.IWMX0.I12.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Iwmx0.I12.MXNA2 ICLKGEN.IEMA.IWMX0.I12.N1
+  ICLKGEN.IEMA.IWMX0.SEL_IN VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Iwmx0.I12.MXPA1 ICLKGEN.IEMA.IWMX0.A0 ICLKGEN.IEMA.WCLK00
+  VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Iwmx0.I12.MXPA2 ICLKGEN.IEMA.IWMX0.A0
+  ICLKGEN.IEMA.IWMX0.SEL_IN VDDPE VNWP P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.Iwmx0.I13.MXNA1 ICLKGEN.IEMA.IWMX0.A1 ICLKGEN.IEMA.WCLK01
+  ICLKGEN.IEMA.IWMX0.I13.N1 VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I13.MXNA2 ICLKGEN.IEMA.IWMX0.I13.N1 EMAW[0] VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I13.MXPA1 ICLKGEN.IEMA.IWMX0.A1 ICLKGEN.IEMA.WCLK01
+  VDDPE VNWP P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I13.MXPA2 ICLKGEN.IEMA.IWMX0.A1 EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I18.MXN0 ICLKGEN.IEMA.WDLY ICLKGEN.IEMA.IWMX0.A0
+  ICLKGEN.IEMA.IWMX0.I18.A1A2 VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I18.MXN1 ICLKGEN.IEMA.WDLY ICLKGEN.IEMA.NCK_IN VSSE VPW
+  N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I18.MXN3 ICLKGEN.IEMA.IWMX0.I18.A1A2
+  ICLKGEN.IEMA.IWMX0.A1 VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx0.I18.MXP0 ICLKGEN.IEMA.WDLY ICLKGEN.IEMA.IWMX0.A0
+  ICLKGEN.IEMA.IWMX0.I18.A1A2UP VNWP P11LL_CKT W=0.71U L=0.04U
X_MIclkgen.Iema.Iwmx0.I18.MXP1 ICLKGEN.IEMA.WDLY ICLKGEN.IEMA.IWMX0.A1
+  ICLKGEN.IEMA.IWMX0.I18.A1A2UP VNWP P11LL_CKT W=0.71U L=0.04U
X_MIclkgen.Iema.Iwmx0.I18.MXP2 ICLKGEN.IEMA.IWMX0.I18.A1A2UP
+  ICLKGEN.IEMA.NCK_IN VDDPE VNWP P11LL_CKT W=0.71U L=0.04U
X_MIclkgen.Iema.Iwmx0.I2.MXNA1 ICLKGEN.IEMA.IWMX0.SEL_IN EMAW[0] VSSE VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIclkgen.Iema.Iwmx0.I2.MXPA1 ICLKGEN.IEMA.IWMX0.SEL_IN EMAW[0] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_MIclkgen.Iema.Iwmx1.I19.MXNA1 ICLKGEN.IEMA.IWMX1.NCK_IN ICLKGEN.IEMA.WCLK10
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx1.I19.MXPA1 ICLKGEN.IEMA.IWMX1.NCK_IN ICLKGEN.IEMA.WCLK10
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_MIclkgen.Iema.Iwmx1.I2.MXNA1 ICLKGEN.IEMA.IWMX1.SEL_IN EMAW[1] VSSE VPW
+  N11LL_CKT W=0.14U L=0.04U
X_MIclkgen.Iema.Iwmx1.I2.MXPA1 ICLKGEN.IEMA.IWMX1.SEL_IN EMAW[1] VDDPE VNWP
+  P11LL_CKT W=0.17U L=0.04U
X_MIclkgen.Iema.Iwmx1.I20.MXNA1 ICLKGEN.IEMA.IWMX1.NCK_DLY ICLKGEN.IEMA.WCLK11
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx1.I20.MXPA1 ICLKGEN.IEMA.IWMX1.NCK_DLY ICLKGEN.IEMA.WCLK11
+  VDDPE VNWP P11LL_CKT W=0.51U L=0.04U
X_MIclkgen.Iema.Iwmx1.I21.MXNOE ICLKGEN.IEMA.IWMX1.NCK_OUT
+  ICLKGEN.IEMA.IWMX1.SEL_IN ICLKGEN.IEMA.IWMX1.NCK_IN VPW N11LL_CKT W=0.425U
+  L=0.04U
X_MIclkgen.Iema.Iwmx1.I21.MXPOEN ICLKGEN.IEMA.IWMX1.NCK_OUT EMAW[1]
+  ICLKGEN.IEMA.IWMX1.NCK_IN VNWP P11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx1.I22.MXNOE ICLKGEN.IEMA.IWMX1.NCK_OUT EMAW[1]
+  ICLKGEN.IEMA.IWMX1.NCK_DLY VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx1.I22.MXPOEN ICLKGEN.IEMA.IWMX1.NCK_OUT
+  ICLKGEN.IEMA.IWMX1.SEL_IN ICLKGEN.IEMA.IWMX1.NCK_DLY VNWP P11LL_CKT
+  W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx1.I23.MXNA1 ICLKGEN.IEMA.WCLK00 ICLKGEN.IEMA.IWMX1.NCK_OUT
+  VSSE VPW N11LL_CKT W=0.425U L=0.04U
X_MIclkgen.Iema.Iwmx1.I23.MXPA1 ICLKGEN.IEMA.WCLK00 ICLKGEN.IEMA.IWMX1.NCK_OUT
+  VDDPE VNWP P11LL_CKT W=0.595U L=0.04U
X_MIclkgen.Iema.MXN0 ICLKGEN.IEMA.NWEMA01 EMAW[0] ICLKGEN.IEMA.NET0124 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.MXN1 ICLKGEN.IEMA.NET0124 NRET VSSE VPW N11LL_CKT W=0.285U
+  L=0.04U
X_MIclkgen.Iema.MXN2 ICLKGEN.IEMA.NGWE DFTRAMBYP ICLKGEN.IEMA.NET057 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.MXN3 ICLKGEN.IEMA.NET057 ICLKGEN.IEMA.WEMA01 VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.MXN4 ICLKGEN.IEMA.NWEMA01 EMAW[1] ICLKGEN.IEMA.NET0124 VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.MXN5 ICLKGEN.IEMA.NGWE GWE ICLKGEN.IEMA.NET057 VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iema.MXP0 ICLKGEN.IEMA.NET0102 EMAW[0] VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iema.MXP1 ICLKGEN.IEMA.NWEMA01 EMAW[1] ICLKGEN.IEMA.NET0102 VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Iema.MXP2 ICLKGEN.IEMA.NWEMA01 NRET VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_MIclkgen.Iema.MXP3 ICLKGEN.IEMA.NET047 DFTRAMBYP VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iema.MXP4 ICLKGEN.IEMA.NGWE GWE ICLKGEN.IEMA.NET047 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Iema.MXP5 ICLKGEN.IEMA.NGWE ICLKGEN.IEMA.WEMA01 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Igtpdwl.MXNA1 GTP_DWL NGTP VSSE VPW N11LL_CKT W=1.71U L=0.04U
X_MIclkgen.Igtpdwl.MXPA1 GTP_DWL NGTP WLDRVDD VNWP P11LL_CKT W=4.26U L=0.04U
X_MIclkgen.Imemgtp.I1.MXNA1 ICLKGEN.IMEMGTP.C1 ICLKGEN.IMEMGTP.NCLK
+  ICLKGEN.IMEMGTP.I1.N1 VPW N11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Imemgtp.I1.MXNA2 ICLKGEN.IMEMGTP.I1.N1 NRET VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Imemgtp.I1.MXPA1 ICLKGEN.IMEMGTP.C1 ICLKGEN.IMEMGTP.NCLK VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Imemgtp.I1.MXPA2 ICLKGEN.IMEMGTP.C1 NRET VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIclkgen.Imemgtp.I24.MXNA1 ICLKGEN.IMEMGTP.C2 NCE ICLKGEN.IMEMGTP.I24.A1A2
+  VPW N11LL_CKT W=0.2U L=0.04U
X_MIclkgen.Imemgtp.I24.MXNA2 ICLKGEN.IMEMGTP.I24.A1A2 ICLKGEN.IMEMGTP.NDFT
+  VSSE VPW N11LL_CKT W=0.2U L=0.04U
X_MIclkgen.Imemgtp.I24.MXNB1 ICLKGEN.IMEMGTP.C2 ICLKGEN.IMEMGTP.C1 VSSE VPW
+  N11LL_CKT W=0.2U L=0.04U
X_MIclkgen.Imemgtp.I24.MXPA1 ICLKGEN.IMEMGTP.C2 NCE ICLKGEN.IMEMGTP.I24.A1A2UP
+  VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Imemgtp.I24.MXPA2 ICLKGEN.IMEMGTP.C2 ICLKGEN.IMEMGTP.NDFT
+  ICLKGEN.IMEMGTP.I24.A1A2UP VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Imemgtp.I24.MXPB1 ICLKGEN.IMEMGTP.I24.A1A2UP ICLKGEN.IMEMGTP.C1
+  VDDPE VNWP P11LL_CKT W=0.57U L=0.04U
X_MIclkgen.Imemgtp.I6.MXNA1 CLK_GTP NGTP VSSE VPW N11LL_CKT W=5.7U L=0.04U
X_MIclkgen.Imemgtp.I6.MXPA1 CLK_GTP NGTP VDDPE VNWP P11LL_CKT W=11.35U L=0.04U
X_MIclkgen.Imemgtp.I68.MXNA1 ICLKGEN.IMEMGTP.FEED NGTP VSSE VPW N11LL_CKT
+  W=0.595U L=0.04U
X_MIclkgen.Imemgtp.I68.MXPA1 ICLKGEN.IMEMGTP.FEED NGTP VDDPE VNWP P11LL_CKT
+  W=0.895U L=0.04U
X_MIclkgen.Imemgtp.I7.MXNA1 ICLKGEN.IMEMGTP.NCLK CLK VSS VPW N11LL_CKT W=4.24U
+  L=0.04U
X_MIclkgen.Imemgtp.I7.MXPA1 ICLKGEN.IMEMGTP.NCLK CLK VDDPE VNWP P11LL_CKT
+  W=4.24U L=0.04U
X_MIclkgen.Imemgtp.I74.MXNA1 ICLKGEN.NFEED ICLKGEN.IMEMGTP.FEED VSSE VPW
+  N11LL_CKT W=0.24U L=0.04U
X_MIclkgen.Imemgtp.I74.MXPA1 ICLKGEN.NFEED ICLKGEN.IMEMGTP.FEED VDDPE VNWP
+  P11LL_CKT W=0.355U L=0.04U
X_MIclkgen.Imemgtp.I82.MXNA1 ICLKGEN.IMEMGTP.CTR ICLKGEN.IMEMGTP.C3 VSSE VPW
+  N11LL_CKT W=0.6U L=0.04U
X_MIclkgen.Imemgtp.I82.MXPA1 ICLKGEN.IMEMGTP.CTR ICLKGEN.IMEMGTP.C3 VDDPE VNWP
+  P11LL_CKT W=1.7U L=0.04U
X_MIclkgen.Imemgtp.I83.MXNA1 ICLKGEN.IMEMGTP.C3 ICLKGEN.IMEMGTP.C2
+  ICLKGEN.IMEMGTP.I83.N1 VPW N11LL_CKT W=0.6U L=0.04U
X_MIclkgen.Imemgtp.I83.MXNA2 ICLKGEN.IMEMGTP.I83.N1 ICLKGEN.NFEED VSSE VPW
+  N11LL_CKT W=0.6U L=0.04U
X_MIclkgen.Imemgtp.I83.MXPA1 ICLKGEN.IMEMGTP.C3 ICLKGEN.IMEMGTP.C2 VDDPE VNWP
+  P11LL_CKT W=0.3U L=0.04U
X_MIclkgen.Imemgtp.I83.MXPA2 ICLKGEN.IMEMGTP.C3 ICLKGEN.NFEED VDDPE VNWP
+  P11LL_CKT W=0.3U L=0.04U
X_MIclkgen.Imemgtp.I86.MXNA1 ICLKGEN.IMEMGTP.NDFT DFTRAMBYP VSS VPW N11LL_CKT
+  W=0.215U L=0.04U
X_MIclkgen.Imemgtp.I86.MXPA1 ICLKGEN.IMEMGTP.NDFT DFTRAMBYP VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIclkgen.Imemgtp.MXN0 ICLKGEN.IMEMGTP.NCLK ICLKGEN.IMEMGTP.CTR NGTP VPW
+  N11LL_CKT W=5.685U L=0.04U
X_MIclkgen.Imemgtp.MXN7 NGTP ICLKGEN.IMEMGTP.FEED ICLKGEN.IMEMGTP.NET114 VPW
+  N11LL_CKT W=0.35U L=0.04U
X_MIclkgen.Imemgtp.MXN8 ICLKGEN.IMEMGTP.NET114 ICLKGEN.RESET VSSE VPW
+  N11LL_CKT W=0.35U L=0.04U
X_MIclkgen.Imemgtp.MXP1 NGTP ICLKGEN.RESET VDDPE VNWP P11LL_CKT W=5.79U
+  L=0.04U
X_MIclkgen.Imemgtp.MXP2 ICLKGEN.IMEMGTP.NET127 ICLKGEN.IMEMGTP.CTR VDDPE VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_MIclkgen.Imemgtp.MXP3 ICLKGEN.IMEMGTP.NET127 CLK VDDPE VNWP P11LL_CKT
+  W=0.48U L=0.04U
X_MIclkgen.Imemgtp.MXP5 NGTP ICLKGEN.IMEMGTP.FEED ICLKGEN.IMEMGTP.NET127 VNWP
+  P11LL_CKT W=0.48U L=0.04U
X_MIclkgen.MXP1 WLDRVDD LOG0 VDDPE VNWP P11LL_CKT W=8.5U L=0.04U
X_MIcmxdummy.I30.MXNA1 ICMXDUMMY.NET71 DBL VSSE VPW N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I30.MXPA1 ICMXDUMMY.NET71 DBL VDDPE VNWP P11LL_CKT W=0.57U
+  L=0.04U
X_MIcmxdummy.I31.MXN11 ICMXDUMMY.I31.NET050 ICMXDUMMY.I31.DI1 VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN12 ICMXDUMMY.I31.NDI1 ICMXDUMMY.I31.DI1
+  ICMXDUMMY.I31.NET050 VPW N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN13 SAE_DUMMY ICMXDUMMY.I31.NDI VSSE VPW N11LL_CKT W=0.6U
+  L=0.04U
X_MIcmxdummy.I31.MXN14 ICMXDUMMY.I31.NET0105 ICMXDUMMY.I31.DI2 VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN15 ICMXDUMMY.I31.NDI2 ICMXDUMMY.I31.DI2
+  ICMXDUMMY.I31.NET0105 VPW N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN16 ICMXDUMMY.I31.DI2 ICMXDUMMY.I31.NDI1 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN17 ICMXDUMMY.I31.DI3 ICMXDUMMY.I31.NDI1 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN18 ICMXDUMMY.I31.NDI3 ICMXDUMMY.I31.DI3
+  ICMXDUMMY.I31.NET081 VPW N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN19 ICMXDUMMY.I31.NET081 ICMXDUMMY.I31.DI3 VSSE VPW
+  N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN3 ICMXDUMMY.I31.NET057 ICMXDUMMY.NET65 VSSE VPW N11LL_CKT
+  W=0.285U L=0.04U
X_MIcmxdummy.I31.MXN4 ICMXDUMMY.I31.DI1 ICMXDUMMY.I31.NDI VSSE VPW N11LL_CKT
+  W=0.14U L=0.04U
X_MIcmxdummy.I31.MXN8 ICMXDUMMY.I31.NDI ICMXDUMMY.NET65 ICMXDUMMY.I31.NET057
+  VPW N11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP0 ICMXDUMMY.I31.NDI ICMXDUMMY.NET65 VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP1 ICMXDUMMY.I31.DI1 ICMXDUMMY.I31.NDI VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP10 ICMXDUMMY.I31.NET036 ICMXDUMMY.I31.NDI1 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP11 ICMXDUMMY.I31.DI3 ICMXDUMMY.I31.NDI1
+  ICMXDUMMY.I31.NET036 VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP3 ICMXDUMMY.I31.NDI1 ICMXDUMMY.I31.DI1 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP5 SAE_DUMMY ICMXDUMMY.I31.NDI VDDPE VNWP P11LL_CKT W=1.2U
+  L=0.04U
X_MIcmxdummy.I31.MXP6 ICMXDUMMY.I31.DI2 ICMXDUMMY.I31.NDI1
+  ICMXDUMMY.I31.NET060 VNWP P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP7 ICMXDUMMY.I31.NET060 ICMXDUMMY.I31.NDI1 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP8 ICMXDUMMY.I31.NDI2 ICMXDUMMY.I31.DI2 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I31.MXP9 ICMXDUMMY.I31.NDI3 ICMXDUMMY.I31.DI3 VDDPE VNWP
+  P11LL_CKT W=0.285U L=0.04U
X_MIcmxdummy.I68.MXNA1 ICMXDUMMY.NET65 DBL VSSE VPW N11LL_CKT W=1.135U L=0.04U
X_MIcmxdummy.I68.MXPA1 ICMXDUMMY.NET65 DBL VDDPE VNWP P11LL_CKT W=2.27U
+  L=0.04U
X_MIcmxdummy.MXN0 VSSE DBL VSSE VPW N11LL_CKT W=1.87U L=0.085U
X_MIcmxdummy.MXN4_0 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_MIcmxdummy.MXN4_1 DBL LOG0 DBL VPW N11LL_CKT W=0.47U L=0.04U
X_MIcmxdummy.MXP1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_MIcmxdummy.MXP1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.485U L=0.04U
X_MIcmxdummy.MXP2 VDDPE DBL VDDPE VNWP P11LL_CKT W=0.485U L=0.04U
X_MIcmxdummy.MXPPU1_0 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_MIcmxdummy.MXPPU1_1 DBL LOG0 DBL VNWP P11LL_CKT W=0.4U L=0.04U
X_MIdbl.Idbl.I2.MXNA1 IDBL.IDBL.NSEL0 EMA[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_MIdbl.Idbl.I2.MXNA2 IDBL.IDBL.NSEL0 EMA[0] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_MIdbl.Idbl.I2.MXPA1 IDBL.IDBL.NSEL0 EMA[2] IDBL.IDBL.I2.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIdbl.Idbl.I2.MXPA2 IDBL.IDBL.I2.P1 EMA[0] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_MIdbl.Idbl.I73.MXNA1 IDBL.IDBL.NIDBL DBL VSSE VPW N11LL_CKT W=0.14U L=0.04U
X_MIdbl.Idbl.I73.MXPA1 IDBL.IDBL.NIDBL DBL VDDPE VNWP P11LL_CKT W=0.17U
+  L=0.04U
X_MIdbl.Idbl.I77.MXNA1 IDBL.IDBL.NSEL1 EMA[2] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_MIdbl.Idbl.I77.MXNA2 IDBL.IDBL.NSEL1 EMA[1] VSSE VPW N11LL_CKT W=0.14U
+  L=0.04U
X_MIdbl.Idbl.I77.MXPA1 IDBL.IDBL.NSEL1 EMA[2] IDBL.IDBL.I77.P1 VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIdbl.Idbl.I77.MXPA2 IDBL.IDBL.I77.P1 EMA[1] VDDPE VNWP P11LL_CKT W=0.285U
+  L=0.04U
X_MIdbl.Idbl.MXN19 DBL GTP_DWL IDBL.IDBL.IA[0] VPW N11LL_CKT W=0.79U L=0.04U
X_MIdbl.Idbl.MXN20 IDBL.IDBL.IA[0] LOG1 VSSE VPW N11LL_CKT W=0.79U L=0.04U
X_MIdbl.Idbl.MXN21 VSSE LOG1 VSSE VPW N11LL_CKT W=0.79U L=0.04U
X_MIdbl.Idbl.MXN22 DBL GTP_DWL IDBL.IDBL.IA[1] VPW N11LL_CKT W=0.48U L=0.04U
X_MIdbl.Idbl.MXN23 IDBL.IDBL.IA[1] IDBL.IDBL.NSEL0 I[0] VPW N11LL_CKT W=0.48U
+  L=0.04U
X_MIdbl.Idbl.MXN24 I[0] LOG1 VSSE VPW N11LL_CKT W=0.48U L=0.04U
X_MIdbl.Idbl.MXN25 DBL GTP_DWL IDBL.IDBL.IA[2] VPW N11LL_CKT W=1.1U L=0.04U
X_MIdbl.Idbl.MXN26 IDBL.IDBL.IA[2] IDBL.IDBL.NSEL1 I[1] VPW N11LL_CKT W=1.1U
+  L=0.04U
X_MIdbl.Idbl.MXN27 I[1] LOG1 VSSE VPW N11LL_CKT W=1.1U L=0.04U
X_MIdbl.Idbl.MXN28 DBL GTP_DWL IDBL.IDBL.IA[3] VPW N11LL_CKT W=1.37U L=0.04U
X_MIdbl.Idbl.MXN29 IDBL.IDBL.IA[3] IDBL.IDBL.NSEL1 I[3] VPW N11LL_CKT W=1.37U
+  L=0.04U
X_MIdbl.Idbl.MXN30 I[3] IDBL.IDBL.NSEL0 VSSE VPW N11LL_CKT W=1.37U L=0.04U
X_MIdbl.Idbl.MXP10 IDBL.IDBL.NET53 IDBL.IDBL.NIDBL VDDPE VNWP P11LL_CKT
+  W=0.285U L=0.04U
X_MIdbl.Idbl.MXP12 DBL GTP_DWL VDDPE VNWP P11LL_CKT W=1.2U L=0.04U
X_MIdbl.Idbl.MXP7 IDBL.IDBL.NET057 IDBL.IDBL.NIDBL VDDPE VNWP P11LL_CKT W=0.2U
+  L=0.04U
X_MIdbl.Idbl.MXP8 DBL LOG1 IDBL.IDBL.NET057 VNWP P11LL_CKT W=0.2U L=0.04U
X_MIdbl.Idbl.MXP9 DBL LOG1 IDBL.IDBL.NET53 VNWP P11LL_CKT W=0.285U L=0.04U
X_MIinv_wrrd_ma_0.I2.MXNA1 WR_MA NWR_MA VSS VPW N11LL_CKT W=2.28U L=0.04U
X_MIinv_wrrd_ma_0.I2.MXPA1 WR_MA NWR_MA VDDPE VNWP P11LL_CKT W=4.53U L=0.04U
X_MIinv_wrrd_ma_1.I2.MXNA1 CADDR[0] NCADDR[0] VSS VPW N11LL_CKT W=2.28U
+  L=0.04U
X_MIinv_wrrd_ma_1.I2.MXPA1 CADDR[0] NCADDR[0] VDDPE VNWP P11LL_CKT W=4.53U
+  L=0.04U
X_MXP0 NCE ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_0 NXPDEC2[0] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_1 NXPDEC2[1] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_2 NXPDEC2[2] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_3 NXPDEC2[3] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_4 NXPDEC2[5] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_5 NXPDEC2[6] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP14_6 NXPDEC2[7] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP1_0 EMA[0] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP1_1 EMA[1] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP1_2 EMA[2] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP2_0 EMAW[0] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP2_1 EMAW[1] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP7_0 CADDR[0] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
X_MXP7_1 CADDR[1] ACTCLMP VDDPE VNWP P11LL_CKT W=0.495U L=0.04U
.ENDS SRAMdpw64d256CNTL_NOTCH
****
.SUBCKT SRAMdpw64d256DPTH1VR64M4 ACTCLMP_0 ACTCLMP_1 BNK_0 BNK_1 CADDR[0]_0
+  CADDR[0]_1 CADDR[1]_0 CADDR[1]_1 CADDR[2]_0 CADDR[2]_1 CADDR[3]_0
+  CADDR[3]_1 CLK_0 CLK_1 CLK_GTP_0 CLK_GTP_1 DA_0 DA_1 DA_2 DA_3 DA_4 DA_5
+  DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16 DA_17 DA_18
+  DA_19 DA_20 DA_21 DA_22 DA_23 DA_24 DA_25 DA_26 DA_27 DA_28 DA_29 DA_30
+  DA_31 DA_32 DA_33 DA_34 DA_35 DA_36 DA_37 DA_38 DA_39 DA_40 DA_41 DA_42
+  DA_43 DA_44 DA_45 DA_46 DA_47 DA_48 DA_49 DA_50 DA_51 DA_52 DA_53 DA_54
+  DA_55 DA_56 DA_57 DA_58 DA_59 DA_60 DA_61 DA_62 DA_63 DBL_0 DBL_1 DB_0 DB_1
+  DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13 DB_14 DB_15
+  DB_16 DB_17 DB_18 DB_19 DB_20 DB_21 DB_22 DB_23 DB_24 DB_25 DB_26 DB_27
+  DB_28 DB_29 DB_30 DB_31 DB_32 DB_33 DB_34 DB_35 DB_36 DB_37 DB_38 DB_39
+  DB_40 DB_41 DB_42 DB_43 DB_44 DB_45 DB_46 DB_47 DB_48 DB_49 DB_50 DB_51
+  DB_52 DB_53 DB_54 DB_55 DB_56 DB_57 DB_58 DB_59 DB_60 DB_61 DB_62 DB_63
+  DFTRAMBYP_0 DFTRAMBYP_1 DFTRAMBYP_BUF_0 DFTRAMBYP_BUF_1 EMAW[0]_0 EMAW[0]_1
+  EMAW[1]_0 EMAW[1]_1 EMA[0]_0 EMA[0]_1 EMA[1]_0 EMA[1]_1 EMA[2]_0 EMA[2]_1
+  LOG0_0 LOG0_1 LOG0_DBL_0 LOG0_DBL_1 LOG0_PG NBNK_0 NBNK_1 NCADDR[0]_0
+  NCADDR[0]_1 NCADDR[1]_0 NCADDR[1]_1 NCE_0 NCE_1 NCLK_CTL_0 NCLK_CTL_1
+  NC_NDFTCRE_0 NC_NDFTCRE_1 NC_SE_0 NC_SE_1 NC_SIG_0 NC_SIG_1 NC_VDDC_0
+  NC_VDDC_1 NC_VDDC_2 NC_VDDC_3 NC_VDDC_4 NC_VDDC_5 NC_VDDC_6 NC_VDDC_7
+  NC_VDDC_8 NC_VDDC_9 NC_VDDC_10 NC_VDDC_11 NC_VDDC_12 NC_VDDC_13 NC_VDDC_14
+  NC_VDDC_15 NC_VDDC_16 NC_VDDC_17 NC_VDDC_18 NC_VDDC_19 NC_VDDC_20
+  NC_VDDC_21 NC_VDDC_22 NC_VDDC_23 NC_VDDC_24 NC_VDDC_25 NC_VDDC_26
+  NC_VDDC_27 NC_VDDC_28 NC_VDDC_29 NC_VDDC_30 NC_VDDC_31 NC_VDDC_32
+  NC_VDDC_33 NC_VDDC_34 NC_VDDC_35 NC_VDDC_36 NC_VDDC_37 NC_VDDC_38
+  NC_VDDC_39 NC_VDDC_40 NC_VDDC_41 NC_VDDC_42 NC_VDDC_43 NC_VDDC_44
+  NC_VDDC_45 NC_VDDC_46 NC_VDDC_47 NC_VDDC_48 NC_VDDC_49 NC_VDDC_50
+  NC_VDDC_51 NC_VDDC_52 NC_VDDC_53 NC_VDDC_54 NC_VDDC_55 NC_VDDC_56
+  NC_VDDC_57 NC_VDDC_58 NC_VDDC_59 NC_VDDC_60 NC_VDDC_61 NC_VDDC_62
+  NC_VDDC_63 NDFTRAMBYPT_0 NDFTRAMBYPT_1 NGWE_0 NGWE_1 NGWE_WT_0 NGWE_WT_1
+  NHDR_WL_0 NHDR_WL_1 NRDT_0 NRDT_1 NRET_0 NRET_1 NRET_ACT_FT1_0
+  NRET_ACT_FT1_1 NRET_ACT_FT2_0 NRET_ACT_FT2_1 NTE_0 NTE_1 NWGSEL_RED_A[0]_0
+  NWGSEL_RED_A[0]_1 NWGSEL_RED_A[0]_2 NWGSEL_RED_A[0]_3 NWGSEL_RED_A[0]_4
+  NWGSEL_RED_A[0]_5 NWGSEL_RED_A[0]_6 NWGSEL_RED_A[0]_7 NWGSEL_RED_A[0]_8
+  NWGSEL_RED_A[0]_9 NWGSEL_RED_A[0]_10 NWGSEL_RED_A[0]_11 NWGSEL_RED_A[0]_12
+  NWGSEL_RED_A[0]_13 NWGSEL_RED_A[0]_14 NWGSEL_RED_A[0]_15 NWGSEL_RED_A[0]_16
+  NWGSEL_RED_A[0]_17 NWGSEL_RED_A[0]_18 NWGSEL_RED_A[0]_19 NWGSEL_RED_A[0]_20
+  NWGSEL_RED_A[0]_21 NWGSEL_RED_A[0]_22 NWGSEL_RED_A[0]_23 NWGSEL_RED_A[0]_24
+  NWGSEL_RED_A[0]_25 NWGSEL_RED_A[0]_26 NWGSEL_RED_A[0]_27 NWGSEL_RED_A[0]_28
+  NWGSEL_RED_A[0]_29 NWGSEL_RED_A[0]_30 NWGSEL_RED_A[0]_31 NWGSEL_RED_A[0]_32
+  NWGSEL_RED_A[0]_33 NWGSEL_RED_A[0]_34 NWGSEL_RED_A[0]_35 NWGSEL_RED_A[0]_36
+  NWGSEL_RED_A[0]_37 NWGSEL_RED_A[0]_38 NWGSEL_RED_A[0]_39 NWGSEL_RED_A[0]_40
+  NWGSEL_RED_A[0]_41 NWGSEL_RED_A[0]_42 NWGSEL_RED_A[0]_43 NWGSEL_RED_A[0]_44
+  NWGSEL_RED_A[0]_45 NWGSEL_RED_A[0]_46 NWGSEL_RED_A[0]_47 NWGSEL_RED_A[0]_48
+  NWGSEL_RED_A[0]_49 NWGSEL_RED_A[0]_50 NWGSEL_RED_A[0]_51 NWGSEL_RED_A[0]_52
+  NWGSEL_RED_A[0]_53 NWGSEL_RED_A[0]_54 NWGSEL_RED_A[0]_55 NWGSEL_RED_A[0]_56
+  NWGSEL_RED_A[0]_57 NWGSEL_RED_A[0]_58 NWGSEL_RED_A[0]_59 NWGSEL_RED_A[0]_60
+  NWGSEL_RED_A[0]_61 NWGSEL_RED_A[0]_62 NWGSEL_RED_A[0]_63 NWGSEL_RED_B[0]_0
+  NWGSEL_RED_B[0]_1 NWGSEL_RED_B[0]_2 NWGSEL_RED_B[0]_3 NWGSEL_RED_B[0]_4
+  NWGSEL_RED_B[0]_5 NWGSEL_RED_B[0]_6 NWGSEL_RED_B[0]_7 NWGSEL_RED_B[0]_8
+  NWGSEL_RED_B[0]_9 NWGSEL_RED_B[0]_10 NWGSEL_RED_B[0]_11 NWGSEL_RED_B[0]_12
+  NWGSEL_RED_B[0]_13 NWGSEL_RED_B[0]_14 NWGSEL_RED_B[0]_15 NWGSEL_RED_B[0]_16
+  NWGSEL_RED_B[0]_17 NWGSEL_RED_B[0]_18 NWGSEL_RED_B[0]_19 NWGSEL_RED_B[0]_20
+  NWGSEL_RED_B[0]_21 NWGSEL_RED_B[0]_22 NWGSEL_RED_B[0]_23 NWGSEL_RED_B[0]_24
+  NWGSEL_RED_B[0]_25 NWGSEL_RED_B[0]_26 NWGSEL_RED_B[0]_27 NWGSEL_RED_B[0]_28
+  NWGSEL_RED_B[0]_29 NWGSEL_RED_B[0]_30 NWGSEL_RED_B[0]_31 NWGSEL_RED_B[0]_32
+  NWGSEL_RED_B[0]_33 NWGSEL_RED_B[0]_34 NWGSEL_RED_B[0]_35 NWGSEL_RED_B[0]_36
+  NWGSEL_RED_B[0]_37 NWGSEL_RED_B[0]_38 NWGSEL_RED_B[0]_39 NWGSEL_RED_B[0]_40
+  NWGSEL_RED_B[0]_41 NWGSEL_RED_B[0]_42 NWGSEL_RED_B[0]_43 NWGSEL_RED_B[0]_44
+  NWGSEL_RED_B[0]_45 NWGSEL_RED_B[0]_46 NWGSEL_RED_B[0]_47 NWGSEL_RED_B[0]_48
+  NWGSEL_RED_B[0]_49 NWGSEL_RED_B[0]_50 NWGSEL_RED_B[0]_51 NWGSEL_RED_B[0]_52
+  NWGSEL_RED_B[0]_53 NWGSEL_RED_B[0]_54 NWGSEL_RED_B[0]_55 NWGSEL_RED_B[0]_56
+  NWGSEL_RED_B[0]_57 NWGSEL_RED_B[0]_58 NWGSEL_RED_B[0]_59 NWGSEL_RED_B[0]_60
+  NWGSEL_RED_B[0]_61 NWGSEL_RED_B[0]_62 NWGSEL_RED_B[0]_63 NWR_MA_0 NWR_MA_1
+  NWTE_0 NWTE_1 NXPDEC1[0]_0 NXPDEC1[0]_1 NXPDEC1[1]_0 NXPDEC1[1]_1
+  NXPDEC1[2]_0 NXPDEC1[2]_1 NXPDEC1[3]_0 NXPDEC1[3]_1 NXPDEC1[4]_0
+  NXPDEC1[4]_1 NXPDEC1[5]_0 NXPDEC1[5]_1 NXPDEC1[6]_0 NXPDEC1[6]_1
+  NXPDEC1[7]_0 NXPDEC1[7]_1 NXPDEC2[0]_0 NXPDEC2[0]_1 NXPDEC2[1]_0
+  NXPDEC2[1]_1 NXPDEC2[2]_0 NXPDEC2[2]_1 NXPDEC2[3]_0 NXPDEC2[3]_1
+  NXPDEC2[4]_0 NXPDEC2[4]_1 NXPDEC2[5]_0 NXPDEC2[5]_1 NXPDEC2[6]_0
+  NXPDEC2[6]_1 NXPDEC2[7]_0 NXPDEC2[7]_1 NXPDEC3[0]_0 NXPDEC3[0]_1
+  NXPDEC3[1]_0 NXPDEC3[1]_1 NXPDEC3[2]_0 NXPDEC3[2]_1 NXPDEC3[3]_0
+  NXPDEC3[3]_1 Q_A_0 Q_A_1 Q_A_2 Q_A_3 Q_A_4 Q_A_5 Q_A_6 Q_A_7 Q_A_8 Q_A_9
+  Q_A_10 Q_A_11 Q_A_12 Q_A_13 Q_A_14 Q_A_15 Q_A_16 Q_A_17 Q_A_18 Q_A_19
+  Q_A_20 Q_A_21 Q_A_22 Q_A_23 Q_A_24 Q_A_25 Q_A_26 Q_A_27 Q_A_28 Q_A_29
+  Q_A_30 Q_A_31 Q_A_32 Q_A_33 Q_A_34 Q_A_35 Q_A_36 Q_A_37 Q_A_38 Q_A_39
+  Q_A_40 Q_A_41 Q_A_42 Q_A_43 Q_A_44 Q_A_45 Q_A_46 Q_A_47 Q_A_48 Q_A_49
+  Q_A_50 Q_A_51 Q_A_52 Q_A_53 Q_A_54 Q_A_55 Q_A_56 Q_A_57 Q_A_58 Q_A_59
+  Q_A_60 Q_A_61 Q_A_62 Q_A_63 Q_B_0 Q_B_1 Q_B_2 Q_B_3 Q_B_4 Q_B_5 Q_B_6 Q_B_7
+  Q_B_8 Q_B_9 Q_B_10 Q_B_11 Q_B_12 Q_B_13 Q_B_14 Q_B_15 Q_B_16 Q_B_17 Q_B_18
+  Q_B_19 Q_B_20 Q_B_21 Q_B_22 Q_B_23 Q_B_24 Q_B_25 Q_B_26 Q_B_27 Q_B_28
+  Q_B_29 Q_B_30 Q_B_31 Q_B_32 Q_B_33 Q_B_34 Q_B_35 Q_B_36 Q_B_37 Q_B_38
+  Q_B_39 Q_B_40 Q_B_41 Q_B_42 Q_B_43 Q_B_44 Q_B_45 Q_B_46 Q_B_47 Q_B_48
+  Q_B_49 Q_B_50 Q_B_51 Q_B_52 Q_B_53 Q_B_54 Q_B_55 Q_B_56 Q_B_57 Q_B_58
+  Q_B_59 Q_B_60 Q_B_61 Q_B_62 Q_B_63 RAM_A_0 RAM_A_1 RAM_A_2 RAM_A_3 RAM_A_4
+  RAM_A_5 RAM_A_6 RAM_A_7 RAM_A_8 RAM_A_9 RAM_A_10 RAM_A_11 RAM_A_12 RAM_A_13
+  RAM_A_14 RAM_A_15 RAM_A_16 RAM_A_17 RAM_A_18 RAM_A_19 RAM_A_20 RAM_A_21
+  RAM_A_22 RAM_A_23 RAM_A_24 RAM_A_25 RAM_A_26 RAM_A_27 RAM_A_28 RAM_A_29
+  RAM_A_30 RAM_A_31 RAM_A_32 RAM_A_33 RAM_A_34 RAM_A_35 RAM_A_36 RAM_A_37
+  RAM_A_38 RAM_A_39 RAM_A_40 RAM_A_41 RAM_A_42 RAM_A_43 RAM_A_44 RAM_A_45
+  RAM_A_46 RAM_A_47 RAM_A_48 RAM_A_49 RAM_A_50 RAM_A_51 RAM_A_52 RAM_A_53
+  RAM_A_54 RAM_A_55 RAM_A_56 RAM_A_57 RAM_A_58 RAM_A_59 RAM_A_60 RAM_A_61
+  RAM_A_62 RAM_A_63 RAM_B_0 RAM_B_1 RAM_B_2 RAM_B_3 RAM_B_4 RAM_B_5 RAM_B_6
+  RAM_B_7 RAM_B_8 RAM_B_9 RAM_B_10 RAM_B_11 RAM_B_12 RAM_B_13 RAM_B_14
+  RAM_B_15 RAM_B_16 RAM_B_17 RAM_B_18 RAM_B_19 RAM_B_20 RAM_B_21 RAM_B_22
+  RAM_B_23 RAM_B_24 RAM_B_25 RAM_B_26 RAM_B_27 RAM_B_28 RAM_B_29 RAM_B_30
+  RAM_B_31 RAM_B_32 RAM_B_33 RAM_B_34 RAM_B_35 RAM_B_36 RAM_B_37 RAM_B_38
+  RAM_B_39 RAM_B_40 RAM_B_41 RAM_B_42 RAM_B_43 RAM_B_44 RAM_B_45 RAM_B_46
+  RAM_B_47 RAM_B_48 RAM_B_49 RAM_B_50 RAM_B_51 RAM_B_52 RAM_B_53 RAM_B_54
+  RAM_B_55 RAM_B_56 RAM_B_57 RAM_B_58 RAM_B_59 RAM_B_60 RAM_B_61 RAM_B_62
+  RAM_B_63 RET_0 RET_1 RE_0 RE_1 SEL_D_0 SEL_D_1 SEL_SI_0 SEL_SI_1 SEL_TD_0
+  SEL_TD_1 SIA_0 SIA_1 SIB_0 SIB_1 SO_A_0 SO_A_1 SO_B_0 SO_B_1 STUB_PEN_CG_0
+  STUB_PEN_CG_1 STUB_TPEN_0 STUB_TPEN_1 TDA_0 TDA_1 TDA_2 TDA_3 TDA_4 TDA_5
+  TDA_6 TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13 TDA_14 TDA_15 TDA_16
+  TDA_17 TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23 TDA_24 TDA_25 TDA_26
+  TDA_27 TDA_28 TDA_29 TDA_30 TDA_31 TDA_32 TDA_33 TDA_34 TDA_35 TDA_36
+  TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43 TDA_44 TDA_45 TDA_46
+  TDA_47 TDA_48 TDA_49 TDA_50 TDA_51 TDA_52 TDA_53 TDA_54 TDA_55 TDA_56
+  TDA_57 TDA_58 TDA_59 TDA_60 TDA_61 TDA_62 TDA_63 TDB_0 TDB_1 TDB_2 TDB_3
+  TDB_4 TDB_5 TDB_6 TDB_7 TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13 TDB_14
+  TDB_15 TDB_16 TDB_17 TDB_18 TDB_19 TDB_20 TDB_21 TDB_22 TDB_23 TDB_24
+  TDB_25 TDB_26 TDB_27 TDB_28 TDB_29 TDB_30 TDB_31 TDB_32 TDB_33 TDB_34
+  TDB_35 TDB_36 TDB_37 TDB_38 TDB_39 TDB_40 TDB_41 TDB_42 TDB_43 TDB_44
+  TDB_45 TDB_46 TDB_47 TDB_48 TDB_49 TDB_50 TDB_51 TDB_52 TDB_53 TDB_54
+  TDB_55 TDB_56 TDB_57 TDB_58 TDB_59 TDB_60 TDB_61 TDB_62 TDB_63 VDDCE VNWC
+  VNWP VPW WDATAO_A[0]_0 WDATAO_A[0]_1 WDATAO_A[0]_2 WDATAO_A[0]_3
+  WDATAO_A[0]_4 WDATAO_A[0]_5 WDATAO_A[0]_6 WDATAO_A[0]_7 WDATAO_A[0]_8
+  WDATAO_A[0]_9 WDATAO_A[0]_10 WDATAO_A[0]_11 WDATAO_A[0]_12 WDATAO_A[0]_13
+  WDATAO_A[0]_14 WDATAO_A[0]_15 WDATAO_A[0]_16 WDATAO_A[0]_17 WDATAO_A[0]_18
+  WDATAO_A[0]_19 WDATAO_A[0]_20 WDATAO_A[0]_21 WDATAO_A[0]_22 WDATAO_A[0]_23
+  WDATAO_A[0]_24 WDATAO_A[0]_25 WDATAO_A[0]_26 WDATAO_A[0]_27 WDATAO_A[0]_28
+  WDATAO_A[0]_29 WDATAO_A[0]_30 WDATAO_A[0]_31 WDATAO_A[0]_32 WDATAO_A[0]_33
+  WDATAO_A[0]_34 WDATAO_A[0]_35 WDATAO_A[0]_36 WDATAO_A[0]_37 WDATAO_A[0]_38
+  WDATAO_A[0]_39 WDATAO_A[0]_40 WDATAO_A[0]_41 WDATAO_A[0]_42 WDATAO_A[0]_43
+  WDATAO_A[0]_44 WDATAO_A[0]_45 WDATAO_A[0]_46 WDATAO_A[0]_47 WDATAO_A[0]_48
+  WDATAO_A[0]_49 WDATAO_A[0]_50 WDATAO_A[0]_51 WDATAO_A[0]_52 WDATAO_A[0]_53
+  WDATAO_A[0]_54 WDATAO_A[0]_55 WDATAO_A[0]_56 WDATAO_A[0]_57 WDATAO_A[0]_58
+  WDATAO_A[0]_59 WDATAO_A[0]_60 WDATAO_A[0]_61 WDATAO_A[0]_62 WDATAO_A[0]_63
+  WDATAO_B[0]_0 WDATAO_B[0]_1 WDATAO_B[0]_2 WDATAO_B[0]_3 WDATAO_B[0]_4
+  WDATAO_B[0]_5 WDATAO_B[0]_6 WDATAO_B[0]_7 WDATAO_B[0]_8 WDATAO_B[0]_9
+  WDATAO_B[0]_10 WDATAO_B[0]_11 WDATAO_B[0]_12 WDATAO_B[0]_13 WDATAO_B[0]_14
+  WDATAO_B[0]_15 WDATAO_B[0]_16 WDATAO_B[0]_17 WDATAO_B[0]_18 WDATAO_B[0]_19
+  WDATAO_B[0]_20 WDATAO_B[0]_21 WDATAO_B[0]_22 WDATAO_B[0]_23 WDATAO_B[0]_24
+  WDATAO_B[0]_25 WDATAO_B[0]_26 WDATAO_B[0]_27 WDATAO_B[0]_28 WDATAO_B[0]_29
+  WDATAO_B[0]_30 WDATAO_B[0]_31 WDATAO_B[0]_32 WDATAO_B[0]_33 WDATAO_B[0]_34
+  WDATAO_B[0]_35 WDATAO_B[0]_36 WDATAO_B[0]_37 WDATAO_B[0]_38 WDATAO_B[0]_39
+  WDATAO_B[0]_40 WDATAO_B[0]_41 WDATAO_B[0]_42 WDATAO_B[0]_43 WDATAO_B[0]_44
+  WDATAO_B[0]_45 WDATAO_B[0]_46 WDATAO_B[0]_47 WDATAO_B[0]_48 WDATAO_B[0]_49
+  WDATAO_B[0]_50 WDATAO_B[0]_51 WDATAO_B[0]_52 WDATAO_B[0]_53 WDATAO_B[0]_54
+  WDATAO_B[0]_55 WDATAO_B[0]_56 WDATAO_B[0]_57 WDATAO_B[0]_58 WDATAO_B[0]_59
+  WDATAO_B[0]_60 WDATAO_B[0]_61 WDATAO_B[0]_62 WDATAO_B[0]_63 WENYA_0 WENYA_1
+  WENYA_2 WENYA_3 WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9 WENYA_10
+  WENYA_11 WENYA_12 WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17 WENYA_18
+  WENYA_19 WENYA_20 WENYA_21 WENYA_22 WENYA_23 WENYA_24 WENYA_25 WENYA_26
+  WENYA_27 WENYA_28 WENYA_29 WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34
+  WENYA_35 WENYA_36 WENYA_37 WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42
+  WENYA_43 WENYA_44 WENYA_45 WENYA_46 WENYA_47 WENYA_48 WENYA_49 WENYA_50
+  WENYA_51 WENYA_52 WENYA_53 WENYA_54 WENYA_55 WENYA_56 WENYA_57 WENYA_58
+  WENYA_59 WENYA_60 WENYA_61 WENYA_62 WENYA_63 WENYB_0 WENYB_1 WENYB_2
+  WENYB_3 WENYB_4 WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11
+  WENYB_12 WENYB_13 WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19
+  WENYB_20 WENYB_21 WENYB_22 WENYB_23 WENYB_24 WENYB_25 WENYB_26 WENYB_27
+  WENYB_28 WENYB_29 WENYB_30 WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35
+  WENYB_36 WENYB_37 WENYB_38 WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43
+  WENYB_44 WENYB_45 WENYB_46 WENYB_47 WENYB_48 WENYB_49 WENYB_50 WENYB_51
+  WENYB_52 WENYB_53 WENYB_54 WENYB_55 WENYB_56 WENYB_57 WENYB_58 WENYB_59
+  WENYB_60 WENYB_61 WENYB_62 WENYB_63 WE_0 WE_1 WR_MA_0 WR_MA_1 WTE_0 WTE_1
** SRAMdpw64d256DPTH1VR64M4: 11660 flat devices **
XCNTL_NOTCH[0] ACTCLMP_0 BNK_0 CADDR[0]_0 CADDR[1]_0 CADDR[2]_0 CADDR[3]_0
+  CLK_0 CLK_DP_A CLK_DP_A CLK_DP_B CLK_GTP_0 DBL_0 DFTRAMBYP_0
+  DFTRAMBYP_BUF_0 EMAW[0]_0 EMAW[1]_0 EMA[0]_0 EMA[1]_0 EMA[2]_0 GTP_DWL
+  SEL_A[0] SEL_A[1] SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SO_A_0 SO_B_0 VPW VPW
+  LOG0_0 LOG0_DBL_0 LOG0_PG NBNK_0 NCADDR[0]_0 NCADDR[1]_0 NCE_0 NCLK_CTL_0
+  NC_NDFTCRE_0 NC_SE_0 NC_SIG_0 NDFTRAMBYP_A NDFTRAMBYPT_0 NDFTRAMBYP_A
+  NDFTRAMBYP_B NGWE_0 NGWE_WT_0 NHDR_WL_0 NRDT_0 NRET_0 NRET_ACT_FT1_0
+  NRET_ACT_FT2_0 NTE_0 NTE_0 NTE_1 NWR_MA_0 NWTE_0 NXPDEC1[0]_0 NXPDEC1[1]_0
+  NXPDEC1[2]_0 NXPDEC1[3]_0 NXPDEC1[4]_0 NXPDEC1[5]_0 NXPDEC1[6]_0
+  NXPDEC1[7]_0 NXPDEC2[0]_0 NXPDEC2[1]_0 NXPDEC2[2]_0 NXPDEC2[3]_0
+  NXPDEC2[4]_0 NXPDEC2[5]_0 NXPDEC2[6]_0 NXPDEC2[7]_0 NXPDEC3[0]_0
+  NXPDEC3[1]_0 NXPDEC3[2]_0 NXPDEC3[3]_0 RE_0 RET_0 SEL_D_0 SEL_D_0 SEL_D_1
+  SEL_SI_0 SEL_SI_0 SEL_SI_1 SEL_TD_0 SEL_TD_0 SEL_TD_1 SO_A_0 SO_B_0
+  STUB_PEN_CG_0 STUB_TPEN_0 LOG0_PG LOG0_PG VNWC VNWP VNWC VNWP VPW VPW VPW
+  WE_0 LOG0_PG LOG0_PG WGSEL_A[0] WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] WR_MA_0 WTE_0 SRAMdpw64d256CNTL_NOTCH
XCNTL_NOTCH[1] ACTCLMP_1 BNK_1 CADDR[0]_1 CADDR[1]_1 CADDR[2]_1 CADDR[3]_1
+  CLK_1 CLK_DP_B CLK_DP_A CLK_DP_B CLK_GTP_1 DBL_1 DFTRAMBYP_1
+  DFTRAMBYP_BUF_1 EMAW[0]_1 EMAW[1]_1 EMA[0]_1 EMA[1]_1 EMA[2]_1 GTP_DWL_17
+  SEL_B[0] SEL_B[1] SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SO_A_1 SO_B_1 VPW VPW
+  LOG0_1 LOG0_DBL_1 LOG0_PG NBNK_1 NCADDR[0]_1 NCADDR[1]_1 NCE_1 NCLK_CTL_1
+  NC_NDFTCRE_1 NC_SE_1 NC_SIG_1 NDFTRAMBYP_B NDFTRAMBYPT_1 NDFTRAMBYP_A
+  NDFTRAMBYP_B NGWE_1 NGWE_WT_1 NHDR_WL_1 NRDT_1 NRET_1 NRET_ACT_FT1_1
+  NRET_ACT_FT2_1 NTE_1 NTE_0 NTE_1 NWR_MA_1 NWTE_1 NXPDEC1[0]_1 NXPDEC1[1]_1
+  NXPDEC1[2]_1 NXPDEC1[3]_1 NXPDEC1[4]_1 NXPDEC1[5]_1 NXPDEC1[6]_1
+  NXPDEC1[7]_1 NXPDEC2[0]_1 NXPDEC2[1]_1 NXPDEC2[2]_1 NXPDEC2[3]_1
+  NXPDEC2[4]_1 NXPDEC2[5]_1 NXPDEC2[6]_1 NXPDEC2[7]_1 NXPDEC3[0]_1
+  NXPDEC3[1]_1 NXPDEC3[2]_1 NXPDEC3[3]_1 RE_1 RET_1 SEL_D_1 SEL_D_0 SEL_D_1
+  SEL_SI_1 SEL_SI_0 SEL_SI_1 SEL_TD_1 SEL_TD_0 SEL_TD_1 SO_A_1 SO_B_1
+  STUB_PEN_CG_1 STUB_TPEN_1 LOG0_PG LOG0_PG VDDCE VNWP VDDCE VNWP VPW VPW VPW
+  WE_1 LOG0_PG LOG0_PG WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3] WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] WR_MA_1 WTE_1 SRAMdpw64d256CNTL_NOTCH
XHDPTHL CLK_DP_A CLK_DP_B DA_31 DA_30 DA_29 DA_28 DA_27 DA_26 DA_25 DA_24
+  DA_23 DA_22 DA_21 DA_20 DA_19 DA_18 DA_17 DA_16 DA_15 DA_14 DA_13 DA_12
+  DA_11 DA_10 DA_9 DA_8 DA_7 DA_6 DA_5 DA_4 DA_3 DA_2 DA_1 DA_0 DB_31 DB_30
+  DB_29 DB_28 DB_27 DB_26 DB_25 DB_24 DB_23 DB_22 DB_21 DB_20 DB_19 DB_18
+  DB_17 DB_16 DB_15 DB_14 DB_13 DB_12 DB_11 DB_10 DB_9 DB_8 DB_7 DB_6 DB_5
+  DB_4 DB_3 DB_2 DB_1 DB_0 GTP_DWL NC_VDDC_31 NC_VDDC_30 NC_VDDC_29
+  NC_VDDC_28 NC_VDDC_27 NC_VDDC_26 NC_VDDC_25 NC_VDDC_24 NC_VDDC_23
+  NC_VDDC_22 NC_VDDC_21 NC_VDDC_20 NC_VDDC_19 NC_VDDC_18 NC_VDDC_17
+  NC_VDDC_16 NC_VDDC_15 NC_VDDC_14 NC_VDDC_13 NC_VDDC_12 NC_VDDC_11
+  NC_VDDC_10 NC_VDDC_9 NC_VDDC_8 NC_VDDC_7 NC_VDDC_6 NC_VDDC_5 NC_VDDC_4
+  NC_VDDC_3 NC_VDDC_2 NC_VDDC_1 NC_VDDC_0 NDFTRAMBYP_A NDFTRAMBYP_B NTE_0
+  NTE_1 NWGSEL_RED_A[0]_31 NWGSEL_RED_A[0]_30 NWGSEL_RED_A[0]_29
+  NWGSEL_RED_A[0]_28 NWGSEL_RED_A[0]_27 NWGSEL_RED_A[0]_26 NWGSEL_RED_A[0]_25
+  NWGSEL_RED_A[0]_24 NWGSEL_RED_A[0]_23 NWGSEL_RED_A[0]_22 NWGSEL_RED_A[0]_21
+  NWGSEL_RED_A[0]_20 NWGSEL_RED_A[0]_19 NWGSEL_RED_A[0]_18 NWGSEL_RED_A[0]_17
+  NWGSEL_RED_A[0]_16 NWGSEL_RED_A[0]_15 NWGSEL_RED_A[0]_14 NWGSEL_RED_A[0]_13
+  NWGSEL_RED_A[0]_12 NWGSEL_RED_A[0]_11 NWGSEL_RED_A[0]_10 NWGSEL_RED_A[0]_9
+  NWGSEL_RED_A[0]_8 NWGSEL_RED_A[0]_7 NWGSEL_RED_A[0]_6 NWGSEL_RED_A[0]_5
+  NWGSEL_RED_A[0]_4 NWGSEL_RED_A[0]_3 NWGSEL_RED_A[0]_2 NWGSEL_RED_A[0]_1
+  NWGSEL_RED_A[0]_0 NWGSEL_RED_B[0]_31 NWGSEL_RED_B[0]_30 NWGSEL_RED_B[0]_29
+  NWGSEL_RED_B[0]_28 NWGSEL_RED_B[0]_27 NWGSEL_RED_B[0]_26 NWGSEL_RED_B[0]_25
+  NWGSEL_RED_B[0]_24 NWGSEL_RED_B[0]_23 NWGSEL_RED_B[0]_22 NWGSEL_RED_B[0]_21
+  NWGSEL_RED_B[0]_20 NWGSEL_RED_B[0]_19 NWGSEL_RED_B[0]_18 NWGSEL_RED_B[0]_17
+  NWGSEL_RED_B[0]_16 NWGSEL_RED_B[0]_15 NWGSEL_RED_B[0]_14 NWGSEL_RED_B[0]_13
+  NWGSEL_RED_B[0]_12 NWGSEL_RED_B[0]_11 NWGSEL_RED_B[0]_10 NWGSEL_RED_B[0]_9
+  NWGSEL_RED_B[0]_8 NWGSEL_RED_B[0]_7 NWGSEL_RED_B[0]_6 NWGSEL_RED_B[0]_5
+  NWGSEL_RED_B[0]_4 NWGSEL_RED_B[0]_3 NWGSEL_RED_B[0]_2 NWGSEL_RED_B[0]_1
+  NWGSEL_RED_B[0]_0 Q_A_31 Q_A_30 Q_A_29 Q_A_28 Q_A_27 Q_A_26 Q_A_25 Q_A_24
+  Q_A_23 Q_A_22 Q_A_21 Q_A_20 Q_A_19 Q_A_18 Q_A_17 Q_A_16 Q_A_15 Q_A_14
+  Q_A_13 Q_A_12 Q_A_11 Q_A_10 Q_A_9 Q_A_8 Q_A_7 Q_A_6 Q_A_5 Q_A_4 Q_A_3 Q_A_2
+  Q_A_1 Q_A_0 Q_B_31 Q_B_30 Q_B_29 Q_B_28 Q_B_27 Q_B_26 Q_B_25 Q_B_24 Q_B_23
+  Q_B_22 Q_B_21 Q_B_20 Q_B_19 Q_B_18 Q_B_17 Q_B_16 Q_B_15 Q_B_14 Q_B_13
+  Q_B_12 Q_B_11 Q_B_10 Q_B_9 Q_B_8 Q_B_7 Q_B_6 Q_B_5 Q_B_4 Q_B_3 Q_B_2 Q_B_1
+  Q_B_0 RAM_A_31 RAM_A_30 RAM_A_29 RAM_A_28 RAM_A_27 RAM_A_26 RAM_A_25
+  RAM_A_24 RAM_A_23 RAM_A_22 RAM_A_21 RAM_A_20 RAM_A_19 RAM_A_18 RAM_A_17
+  RAM_A_16 RAM_A_15 RAM_A_14 RAM_A_13 RAM_A_12 RAM_A_11 RAM_A_10 RAM_A_9
+  RAM_A_8 RAM_A_7 RAM_A_6 RAM_A_5 RAM_A_4 RAM_A_3 RAM_A_2 RAM_A_1 RAM_A_0
+  RAM_B_31 RAM_B_30 RAM_B_29 RAM_B_28 RAM_B_27 RAM_B_26 RAM_B_25 RAM_B_24
+  RAM_B_23 RAM_B_22 RAM_B_21 RAM_B_20 RAM_B_19 RAM_B_18 RAM_B_17 RAM_B_16
+  RAM_B_15 RAM_B_14 RAM_B_13 RAM_B_12 RAM_B_11 RAM_B_10 RAM_B_9 RAM_B_8
+  RAM_B_7 RAM_B_6 RAM_B_5 RAM_B_4 RAM_B_3 RAM_B_2 RAM_B_1 RAM_B_0 SEL_A[0]
+  SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_0 SEL_D_1 SEL_SI_0 SEL_SI_1 SEL_TD_0
+  SEL_TD_1 SIA_0 SIB_0 SO_A_0 SO_B_0 TDA_31 TDA_30 TDA_29 TDA_28 TDA_27
+  TDA_26 TDA_25 TDA_24 TDA_23 TDA_22 TDA_21 TDA_20 TDA_19 TDA_18 TDA_17
+  TDA_16 TDA_15 TDA_14 TDA_13 TDA_12 TDA_11 TDA_10 TDA_9 TDA_8 TDA_7 TDA_6
+  TDA_5 TDA_4 TDA_3 TDA_2 TDA_1 TDA_0 TDB_31 TDB_30 TDB_29 TDB_28 TDB_27
+  TDB_26 TDB_25 TDB_24 TDB_23 TDB_22 TDB_21 TDB_20 TDB_19 TDB_18 TDB_17
+  TDB_16 TDB_15 TDB_14 TDB_13 TDB_12 TDB_11 TDB_10 TDB_9 TDB_8 TDB_7 TDB_6
+  TDB_5 TDB_4 TDB_3 TDB_2 TDB_1 TDB_0 LOG0_PG LOG0_PG VNWC VNWP VPW
+  WDATAO_A[0]_31 WDATAO_A[0]_30 WDATAO_A[0]_29 WDATAO_A[0]_28 WDATAO_A[0]_27
+  WDATAO_A[0]_26 WDATAO_A[0]_25 WDATAO_A[0]_24 WDATAO_A[0]_23 WDATAO_A[0]_22
+  WDATAO_A[0]_21 WDATAO_A[0]_20 WDATAO_A[0]_19 WDATAO_A[0]_18 WDATAO_A[0]_17
+  WDATAO_A[0]_16 WDATAO_A[0]_15 WDATAO_A[0]_14 WDATAO_A[0]_13 WDATAO_A[0]_12
+  WDATAO_A[0]_11 WDATAO_A[0]_10 WDATAO_A[0]_9 WDATAO_A[0]_8 WDATAO_A[0]_7
+  WDATAO_A[0]_6 WDATAO_A[0]_5 WDATAO_A[0]_4 WDATAO_A[0]_3 WDATAO_A[0]_2
+  WDATAO_A[0]_1 WDATAO_A[0]_0 WDATAO_B[0]_31 WDATAO_B[0]_30 WDATAO_B[0]_29
+  WDATAO_B[0]_28 WDATAO_B[0]_27 WDATAO_B[0]_26 WDATAO_B[0]_25 WDATAO_B[0]_24
+  WDATAO_B[0]_23 WDATAO_B[0]_22 WDATAO_B[0]_21 WDATAO_B[0]_20 WDATAO_B[0]_19
+  WDATAO_B[0]_18 WDATAO_B[0]_17 WDATAO_B[0]_16 WDATAO_B[0]_15 WDATAO_B[0]_14
+  WDATAO_B[0]_13 WDATAO_B[0]_12 WDATAO_B[0]_11 WDATAO_B[0]_10 WDATAO_B[0]_9
+  WDATAO_B[0]_8 WDATAO_B[0]_7 WDATAO_B[0]_6 WDATAO_B[0]_5 WDATAO_B[0]_4
+  WDATAO_B[0]_3 WDATAO_B[0]_2 WDATAO_B[0]_1 WDATAO_B[0]_0 LOG0_PG LOG0_PG
+  WENYA_31 WENYA_30 WENYA_29 WENYA_28 WENYA_27 WENYA_26 WENYA_25 WENYA_24
+  WENYA_23 WENYA_22 WENYA_21 WENYA_20 WENYA_19 WENYA_18 WENYA_17 WENYA_16
+  WENYA_15 WENYA_14 WENYA_13 WENYA_12 WENYA_11 WENYA_10 WENYA_9 WENYA_8
+  WENYA_7 WENYA_6 WENYA_5 WENYA_4 WENYA_3 WENYA_2 WENYA_1 WENYA_0 WENYB_31
+  WENYB_30 WENYB_29 WENYB_28 WENYB_27 WENYB_26 WENYB_25 WENYB_24 WENYB_23
+  WENYB_22 WENYB_21 WENYB_20 WENYB_19 WENYB_18 WENYB_17 WENYB_16 WENYB_15
+  WENYB_14 WENYB_13 WENYB_12 WENYB_11 WENYB_10 WENYB_9 WENYB_8 WENYB_7
+  WENYB_6 WENYB_5 WENYB_4 WENYB_3 WENYB_2 WENYB_1 WENYB_0 WGSEL_A[0]
+  WGSEL_A[1] WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2]
+  WGSEL_B[3] SRAMdpw64d256DPTHSEC0_32O4L
XHDPTHR CLK_DP_A CLK_DP_B DA_32 DA_33 DA_34 DA_35 DA_36 DA_37 DA_38 DA_39
+  DA_40 DA_41 DA_42 DA_43 DA_44 DA_45 DA_46 DA_47 DA_48 DA_49 DA_50 DA_51
+  DA_52 DA_53 DA_54 DA_55 DA_56 DA_57 DA_58 DA_59 DA_60 DA_61 DA_62 DA_63
+  DB_32 DB_33 DB_34 DB_35 DB_36 DB_37 DB_38 DB_39 DB_40 DB_41 DB_42 DB_43
+  DB_44 DB_45 DB_46 DB_47 DB_48 DB_49 DB_50 DB_51 DB_52 DB_53 DB_54 DB_55
+  DB_56 DB_57 DB_58 DB_59 DB_60 DB_61 DB_62 DB_63 GTP_DWL_17 NC_VDDC_32
+  NC_VDDC_33 NC_VDDC_34 NC_VDDC_35 NC_VDDC_36 NC_VDDC_37 NC_VDDC_38
+  NC_VDDC_39 NC_VDDC_40 NC_VDDC_41 NC_VDDC_42 NC_VDDC_43 NC_VDDC_44
+  NC_VDDC_45 NC_VDDC_46 NC_VDDC_47 NC_VDDC_48 NC_VDDC_49 NC_VDDC_50
+  NC_VDDC_51 NC_VDDC_52 NC_VDDC_53 NC_VDDC_54 NC_VDDC_55 NC_VDDC_56
+  NC_VDDC_57 NC_VDDC_58 NC_VDDC_59 NC_VDDC_60 NC_VDDC_61 NC_VDDC_62
+  NC_VDDC_63 NDFTRAMBYP_A NDFTRAMBYP_B NTE_0 NTE_1 NWGSEL_RED_A[0]_32
+  NWGSEL_RED_A[0]_33 NWGSEL_RED_A[0]_34 NWGSEL_RED_A[0]_35 NWGSEL_RED_A[0]_36
+  NWGSEL_RED_A[0]_37 NWGSEL_RED_A[0]_38 NWGSEL_RED_A[0]_39 NWGSEL_RED_A[0]_40
+  NWGSEL_RED_A[0]_41 NWGSEL_RED_A[0]_42 NWGSEL_RED_A[0]_43 NWGSEL_RED_A[0]_44
+  NWGSEL_RED_A[0]_45 NWGSEL_RED_A[0]_46 NWGSEL_RED_A[0]_47 NWGSEL_RED_A[0]_48
+  NWGSEL_RED_A[0]_49 NWGSEL_RED_A[0]_50 NWGSEL_RED_A[0]_51 NWGSEL_RED_A[0]_52
+  NWGSEL_RED_A[0]_53 NWGSEL_RED_A[0]_54 NWGSEL_RED_A[0]_55 NWGSEL_RED_A[0]_56
+  NWGSEL_RED_A[0]_57 NWGSEL_RED_A[0]_58 NWGSEL_RED_A[0]_59 NWGSEL_RED_A[0]_60
+  NWGSEL_RED_A[0]_61 NWGSEL_RED_A[0]_62 NWGSEL_RED_A[0]_63 NWGSEL_RED_B[0]_32
+  NWGSEL_RED_B[0]_33 NWGSEL_RED_B[0]_34 NWGSEL_RED_B[0]_35 NWGSEL_RED_B[0]_36
+  NWGSEL_RED_B[0]_37 NWGSEL_RED_B[0]_38 NWGSEL_RED_B[0]_39 NWGSEL_RED_B[0]_40
+  NWGSEL_RED_B[0]_41 NWGSEL_RED_B[0]_42 NWGSEL_RED_B[0]_43 NWGSEL_RED_B[0]_44
+  NWGSEL_RED_B[0]_45 NWGSEL_RED_B[0]_46 NWGSEL_RED_B[0]_47 NWGSEL_RED_B[0]_48
+  NWGSEL_RED_B[0]_49 NWGSEL_RED_B[0]_50 NWGSEL_RED_B[0]_51 NWGSEL_RED_B[0]_52
+  NWGSEL_RED_B[0]_53 NWGSEL_RED_B[0]_54 NWGSEL_RED_B[0]_55 NWGSEL_RED_B[0]_56
+  NWGSEL_RED_B[0]_57 NWGSEL_RED_B[0]_58 NWGSEL_RED_B[0]_59 NWGSEL_RED_B[0]_60
+  NWGSEL_RED_B[0]_61 NWGSEL_RED_B[0]_62 NWGSEL_RED_B[0]_63 Q_A_32 Q_A_33
+  Q_A_34 Q_A_35 Q_A_36 Q_A_37 Q_A_38 Q_A_39 Q_A_40 Q_A_41 Q_A_42 Q_A_43
+  Q_A_44 Q_A_45 Q_A_46 Q_A_47 Q_A_48 Q_A_49 Q_A_50 Q_A_51 Q_A_52 Q_A_53
+  Q_A_54 Q_A_55 Q_A_56 Q_A_57 Q_A_58 Q_A_59 Q_A_60 Q_A_61 Q_A_62 Q_A_63
+  Q_B_32 Q_B_33 Q_B_34 Q_B_35 Q_B_36 Q_B_37 Q_B_38 Q_B_39 Q_B_40 Q_B_41
+  Q_B_42 Q_B_43 Q_B_44 Q_B_45 Q_B_46 Q_B_47 Q_B_48 Q_B_49 Q_B_50 Q_B_51
+  Q_B_52 Q_B_53 Q_B_54 Q_B_55 Q_B_56 Q_B_57 Q_B_58 Q_B_59 Q_B_60 Q_B_61
+  Q_B_62 Q_B_63 RAM_A_32 RAM_A_33 RAM_A_34 RAM_A_35 RAM_A_36 RAM_A_37
+  RAM_A_38 RAM_A_39 RAM_A_40 RAM_A_41 RAM_A_42 RAM_A_43 RAM_A_44 RAM_A_45
+  RAM_A_46 RAM_A_47 RAM_A_48 RAM_A_49 RAM_A_50 RAM_A_51 RAM_A_52 RAM_A_53
+  RAM_A_54 RAM_A_55 RAM_A_56 RAM_A_57 RAM_A_58 RAM_A_59 RAM_A_60 RAM_A_61
+  RAM_A_62 RAM_A_63 RAM_B_32 RAM_B_33 RAM_B_34 RAM_B_35 RAM_B_36 RAM_B_37
+  RAM_B_38 RAM_B_39 RAM_B_40 RAM_B_41 RAM_B_42 RAM_B_43 RAM_B_44 RAM_B_45
+  RAM_B_46 RAM_B_47 RAM_B_48 RAM_B_49 RAM_B_50 RAM_B_51 RAM_B_52 RAM_B_53
+  RAM_B_54 RAM_B_55 RAM_B_56 RAM_B_57 RAM_B_58 RAM_B_59 RAM_B_60 RAM_B_61
+  RAM_B_62 RAM_B_63 SEL_A[0] SEL_A[1] SEL_B[0] SEL_B[1] SEL_D_0 SEL_D_1
+  SEL_SI_0 SEL_SI_1 SEL_TD_0 SEL_TD_1 SIA_1 SIB_1 SO_A_1 SO_B_1 TDA_32 TDA_33
+  TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43
+  TDA_44 TDA_45 TDA_46 TDA_47 TDA_48 TDA_49 TDA_50 TDA_51 TDA_52 TDA_53
+  TDA_54 TDA_55 TDA_56 TDA_57 TDA_58 TDA_59 TDA_60 TDA_61 TDA_62 TDA_63
+  TDB_32 TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38 TDB_39 TDB_40 TDB_41
+  TDB_42 TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TDB_48 TDB_49 TDB_50 TDB_51
+  TDB_52 TDB_53 TDB_54 TDB_55 TDB_56 TDB_57 TDB_58 TDB_59 TDB_60 TDB_61
+  TDB_62 TDB_63 LOG0_PG LOG0_PG VDDCE VNWP VPW WDATAO_A[0]_32 WDATAO_A[0]_33
+  WDATAO_A[0]_34 WDATAO_A[0]_35 WDATAO_A[0]_36 WDATAO_A[0]_37 WDATAO_A[0]_38
+  WDATAO_A[0]_39 WDATAO_A[0]_40 WDATAO_A[0]_41 WDATAO_A[0]_42 WDATAO_A[0]_43
+  WDATAO_A[0]_44 WDATAO_A[0]_45 WDATAO_A[0]_46 WDATAO_A[0]_47 WDATAO_A[0]_48
+  WDATAO_A[0]_49 WDATAO_A[0]_50 WDATAO_A[0]_51 WDATAO_A[0]_52 WDATAO_A[0]_53
+  WDATAO_A[0]_54 WDATAO_A[0]_55 WDATAO_A[0]_56 WDATAO_A[0]_57 WDATAO_A[0]_58
+  WDATAO_A[0]_59 WDATAO_A[0]_60 WDATAO_A[0]_61 WDATAO_A[0]_62 WDATAO_A[0]_63
+  WDATAO_B[0]_32 WDATAO_B[0]_33 WDATAO_B[0]_34 WDATAO_B[0]_35 WDATAO_B[0]_36
+  WDATAO_B[0]_37 WDATAO_B[0]_38 WDATAO_B[0]_39 WDATAO_B[0]_40 WDATAO_B[0]_41
+  WDATAO_B[0]_42 WDATAO_B[0]_43 WDATAO_B[0]_44 WDATAO_B[0]_45 WDATAO_B[0]_46
+  WDATAO_B[0]_47 WDATAO_B[0]_48 WDATAO_B[0]_49 WDATAO_B[0]_50 WDATAO_B[0]_51
+  WDATAO_B[0]_52 WDATAO_B[0]_53 WDATAO_B[0]_54 WDATAO_B[0]_55 WDATAO_B[0]_56
+  WDATAO_B[0]_57 WDATAO_B[0]_58 WDATAO_B[0]_59 WDATAO_B[0]_60 WDATAO_B[0]_61
+  WDATAO_B[0]_62 WDATAO_B[0]_63 LOG0_PG LOG0_PG WENYA_32 WENYA_33 WENYA_34
+  WENYA_35 WENYA_36 WENYA_37 WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42
+  WENYA_43 WENYA_44 WENYA_45 WENYA_46 WENYA_47 WENYA_48 WENYA_49 WENYA_50
+  WENYA_51 WENYA_52 WENYA_53 WENYA_54 WENYA_55 WENYA_56 WENYA_57 WENYA_58
+  WENYA_59 WENYA_60 WENYA_61 WENYA_62 WENYA_63 WENYB_32 WENYB_33 WENYB_34
+  WENYB_35 WENYB_36 WENYB_37 WENYB_38 WENYB_39 WENYB_40 WENYB_41 WENYB_42
+  WENYB_43 WENYB_44 WENYB_45 WENYB_46 WENYB_47 WENYB_48 WENYB_49 WENYB_50
+  WENYB_51 WENYB_52 WENYB_53 WENYB_54 WENYB_55 WENYB_56 WENYB_57 WENYB_58
+  WENYB_59 WENYB_60 WENYB_61 WENYB_62 WENYB_63 WGSEL_A[0] WGSEL_A[1]
+  WGSEL_A[2] WGSEL_A[3] WGSEL_B[0] WGSEL_B[1] WGSEL_B[2] WGSEL_B[3]
+  SRAMdpw64d256DPTHSEC0_32O4R
.ENDS SRAMdpw64d256DPTH1VR64M4
****
.SUBCKT SRAMdpw64d256IOARRAY64 ACTCLMP_0 ACTCLMP_1 BNK_0 BNK_1 CAA[0] CAA[1]
+  CAA[2] CAB[0] CAB[1] CADDR[0]_0 CADDR[0]_1 CADDR[1]_0 CADDR[1]_1 CAYA[0]
+  CAYA[1] CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2] CAYB[3] CENA CENB CENYA
+  CENYB CLKA CLKB CLK_GTP_0 CLK_GTP_1 COLLDISN DA[0] DA[1] DA[2] DA[3] DA[4]
+  DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14] DA[15]
+  DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12 DA_13
+  DA_14 DA_15 DA_16 DA_17 DA_18 DA_19 DA_20 DA_21 DA_22 DA_23 DA_24 DA_25
+  DA_26 DA_27 DA_28 DA_29 DA_30 DA_31 DA_32 DA_33 DA_34 DA_35 DA_36 DA_37
+  DA_38 DA_39 DA_40 DA_41 DA_42 DA_43 DA_44 DA_45 DA_46 DA_47 DBL_0 DBL_1
+  DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11]
+  DB[12] DB[13] DB[14] DB[15] DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8
+  DB_9 DB_10 DB_11 DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20
+  DB_21 DB_22 DB_23 DB_24 DB_25 DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 DB_32
+  DB_33 DB_34 DB_35 DB_36 DB_37 DB_38 DB_39 DB_40 DB_41 DB_42 DB_43 DB_44
+  DB_45 DB_46 DB_47 DFTRAMBYP EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2]
+  EMAWA[0] EMAWA[1] EMAWB[0] EMAWB[1] GWENA GWENB GWENYA GWENYB LOG0_DBL
+  NC_VDDC_0 NC_VDDC_1 NC_VDDC_2 NC_VDDC_3 NC_VDDC_4 NC_VDDC_5 NC_VDDC_6
+  NC_VDDC_7 NC_VDDC_8 NC_VDDC_9 NC_VDDC_10 NC_VDDC_11 NC_VDDC_12 NC_VDDC_13
+  NC_VDDC_14 NC_VDDC_15 NC_VDDC_16 NC_VDDC_17 NC_VDDC_18 NC_VDDC_19
+  NC_VDDC_20 NC_VDDC_21 NC_VDDC_22 NC_VDDC_23 NC_VDDC_24 NC_VDDC_25
+  NC_VDDC_26 NC_VDDC_27 NC_VDDC_28 NC_VDDC_29 NC_VDDC_30 NC_VDDC_31
+  NC_VDDC_32 NC_VDDC_33 NC_VDDC_34 NC_VDDC_35 NC_VDDC_36 NC_VDDC_37
+  NC_VDDC_38 NC_VDDC_39 NC_VDDC_40 NC_VDDC_41 NC_VDDC_42 NC_VDDC_43
+  NC_VDDC_44 NC_VDDC_45 NC_VDDC_46 NC_VDDC_47 NC_VDDC_48 NC_VDDC_49
+  NC_VDDC_50 NC_VDDC_51 NC_VDDC_52 NC_VDDC_53 NC_VDDC_54 NC_VDDC_55
+  NC_VDDC_56 NC_VDDC_57 NC_VDDC_58 NC_VDDC_59 NC_VDDC_60 NC_VDDC_61
+  NC_VDDC_62 NC_VDDC_63 NDFTRAMBYPT_0 NDFTRAMBYPT_1 NHDR_WL_0 NHDR_WL_1
+  NRDT_0 NRDT_1 NRET_ACT_FT1_0 NRET_ACT_FT1_1 NRET_ACT_FT2 NWGSEL_RED_A[0]_0
+  NWGSEL_RED_A[0]_1 NWGSEL_RED_A[0]_2 NWGSEL_RED_A[0]_3 NWGSEL_RED_A[0]_4
+  NWGSEL_RED_A[0]_5 NWGSEL_RED_A[0]_6 NWGSEL_RED_A[0]_7 NWGSEL_RED_A[0]_8
+  NWGSEL_RED_A[0]_9 NWGSEL_RED_A[0]_10 NWGSEL_RED_A[0]_11 NWGSEL_RED_A[0]_12
+  NWGSEL_RED_A[0]_13 NWGSEL_RED_A[0]_14 NWGSEL_RED_A[0]_15 NWGSEL_RED_A[0]_16
+  NWGSEL_RED_A[0]_17 NWGSEL_RED_A[0]_18 NWGSEL_RED_A[0]_19 NWGSEL_RED_A[0]_20
+  NWGSEL_RED_A[0]_21 NWGSEL_RED_A[0]_22 NWGSEL_RED_A[0]_23 NWGSEL_RED_A[0]_24
+  NWGSEL_RED_A[0]_25 NWGSEL_RED_A[0]_26 NWGSEL_RED_A[0]_27 NWGSEL_RED_A[0]_28
+  NWGSEL_RED_A[0]_29 NWGSEL_RED_A[0]_30 NWGSEL_RED_A[0]_31 NWGSEL_RED_A[0]_32
+  NWGSEL_RED_A[0]_33 NWGSEL_RED_A[0]_34 NWGSEL_RED_A[0]_35 NWGSEL_RED_A[0]_36
+  NWGSEL_RED_A[0]_37 NWGSEL_RED_A[0]_38 NWGSEL_RED_A[0]_39 NWGSEL_RED_A[0]_40
+  NWGSEL_RED_A[0]_41 NWGSEL_RED_A[0]_42 NWGSEL_RED_A[0]_43 NWGSEL_RED_A[0]_44
+  NWGSEL_RED_A[0]_45 NWGSEL_RED_A[0]_46 NWGSEL_RED_A[0]_47 NWGSEL_RED_A[0]_48
+  NWGSEL_RED_A[0]_49 NWGSEL_RED_A[0]_50 NWGSEL_RED_A[0]_51 NWGSEL_RED_A[0]_52
+  NWGSEL_RED_A[0]_53 NWGSEL_RED_A[0]_54 NWGSEL_RED_A[0]_55 NWGSEL_RED_A[0]_56
+  NWGSEL_RED_A[0]_57 NWGSEL_RED_A[0]_58 NWGSEL_RED_A[0]_59 NWGSEL_RED_A[0]_60
+  NWGSEL_RED_A[0]_61 NWGSEL_RED_A[0]_62 NWGSEL_RED_A[0]_63 NWGSEL_RED_B[0]_0
+  NWGSEL_RED_B[0]_1 NWGSEL_RED_B[0]_2 NWGSEL_RED_B[0]_3 NWGSEL_RED_B[0]_4
+  NWGSEL_RED_B[0]_5 NWGSEL_RED_B[0]_6 NWGSEL_RED_B[0]_7 NWGSEL_RED_B[0]_8
+  NWGSEL_RED_B[0]_9 NWGSEL_RED_B[0]_10 NWGSEL_RED_B[0]_11 NWGSEL_RED_B[0]_12
+  NWGSEL_RED_B[0]_13 NWGSEL_RED_B[0]_14 NWGSEL_RED_B[0]_15 NWGSEL_RED_B[0]_16
+  NWGSEL_RED_B[0]_17 NWGSEL_RED_B[0]_18 NWGSEL_RED_B[0]_19 NWGSEL_RED_B[0]_20
+  NWGSEL_RED_B[0]_21 NWGSEL_RED_B[0]_22 NWGSEL_RED_B[0]_23 NWGSEL_RED_B[0]_24
+  NWGSEL_RED_B[0]_25 NWGSEL_RED_B[0]_26 NWGSEL_RED_B[0]_27 NWGSEL_RED_B[0]_28
+  NWGSEL_RED_B[0]_29 NWGSEL_RED_B[0]_30 NWGSEL_RED_B[0]_31 NWGSEL_RED_B[0]_32
+  NWGSEL_RED_B[0]_33 NWGSEL_RED_B[0]_34 NWGSEL_RED_B[0]_35 NWGSEL_RED_B[0]_36
+  NWGSEL_RED_B[0]_37 NWGSEL_RED_B[0]_38 NWGSEL_RED_B[0]_39 NWGSEL_RED_B[0]_40
+  NWGSEL_RED_B[0]_41 NWGSEL_RED_B[0]_42 NWGSEL_RED_B[0]_43 NWGSEL_RED_B[0]_44
+  NWGSEL_RED_B[0]_45 NWGSEL_RED_B[0]_46 NWGSEL_RED_B[0]_47 NWGSEL_RED_B[0]_48
+  NWGSEL_RED_B[0]_49 NWGSEL_RED_B[0]_50 NWGSEL_RED_B[0]_51 NWGSEL_RED_B[0]_52
+  NWGSEL_RED_B[0]_53 NWGSEL_RED_B[0]_54 NWGSEL_RED_B[0]_55 NWGSEL_RED_B[0]_56
+  NWGSEL_RED_B[0]_57 NWGSEL_RED_B[0]_58 NWGSEL_RED_B[0]_59 NWGSEL_RED_B[0]_60
+  NWGSEL_RED_B[0]_61 NWGSEL_RED_B[0]_62 NWGSEL_RED_B[0]_63 NXPDEC1[0]_0
+  NXPDEC1[0]_1 NXPDEC1[1]_0 NXPDEC1[1]_1 NXPDEC1[2]_0 NXPDEC1[2]_1
+  NXPDEC1[3]_0 NXPDEC1[3]_1 NXPDEC1[4]_0 NXPDEC1[4]_1 NXPDEC1[5]_0
+  NXPDEC1[5]_1 NXPDEC1[6]_0 NXPDEC1[6]_1 NXPDEC1[7]_0 NXPDEC1[7]_1
+  NXPDEC2[0]_0 NXPDEC2[0]_1 NXPDEC2[1]_0 NXPDEC2[1]_1 NXPDEC2[2]_0
+  NXPDEC2[2]_1 NXPDEC2[3]_0 NXPDEC2[3]_1 NXPDEC2[4]_0 NXPDEC2[4]_1
+  NXPDEC2[5]_0 NXPDEC2[5]_1 NXPDEC2[6]_0 NXPDEC2[6]_1 NXPDEC2[7]_0
+  NXPDEC2[7]_1 NXPDEC3[0]_0 NXPDEC3[0]_1 NXPDEC3[1]_0 NXPDEC3[1]_1
+  NXPDEC3[2]_0 NXPDEC3[2]_1 NXPDEC3[3]_0 NXPDEC3[3]_1 PENSOA PENSOB PSOA[0]
+  PSOA[1] PSOB[0] PSOB[1] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7]
+  QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] QA_0 QA_1 QA_2 QA_3
+  QA_4 QA_5 QA_6 QA_7 QA_8 QA_9 QA_10 QA_11 QA_12 QA_13 QA_14 QA_15 QA_16
+  QA_17 QA_18 QA_19 QA_20 QA_21 QA_22 QA_23 QA_24 QA_25 QA_26 QA_27 QA_28
+  QA_29 QA_30 QA_31 QA_32 QA_33 QA_34 QA_35 QA_36 QA_37 QA_38 QA_39 QA_40
+  QA_41 QA_42 QA_43 QA_44 QA_45 QA_46 QA_47 QB[0] QB[1] QB[2] QB[3] QB[4]
+  QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15]
+  QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7 QB_8 QB_9 QB_10 QB_11 QB_12 QB_13
+  QB_14 QB_15 QB_16 QB_17 QB_18 QB_19 QB_20 QB_21 QB_22 QB_23 QB_24 QB_25
+  QB_26 QB_27 QB_28 QB_29 QB_30 QB_31 QB_32 QB_33 QB_34 QB_35 QB_36 QB_37
+  QB_38 QB_39 QB_40 QB_41 QB_42 QB_43 QB_44 QB_45 QB_46 QB_47 RAA[0] RAA[1]
+  RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5]
+  RAM_A_0 RAM_A_1 RAM_A_2 RAM_A_3 RAM_A_4 RAM_A_5 RAM_A_6 RAM_A_7 RAM_A_8
+  RAM_A_9 RAM_A_10 RAM_A_11 RAM_A_12 RAM_A_13 RAM_A_14 RAM_A_15 RAM_A_16
+  RAM_A_17 RAM_A_18 RAM_A_19 RAM_A_20 RAM_A_21 RAM_A_22 RAM_A_23 RAM_A_24
+  RAM_A_25 RAM_A_26 RAM_A_27 RAM_A_28 RAM_A_29 RAM_A_30 RAM_A_31 RAM_A_32
+  RAM_A_33 RAM_A_34 RAM_A_35 RAM_A_36 RAM_A_37 RAM_A_38 RAM_A_39 RAM_A_40
+  RAM_A_41 RAM_A_42 RAM_A_43 RAM_A_44 RAM_A_45 RAM_A_46 RAM_A_47 RAM_A_48
+  RAM_A_49 RAM_A_50 RAM_A_51 RAM_A_52 RAM_A_53 RAM_A_54 RAM_A_55 RAM_A_56
+  RAM_A_57 RAM_A_58 RAM_A_59 RAM_A_60 RAM_A_61 RAM_A_62 RAM_A_63 RAM_B_0
+  RAM_B_1 RAM_B_2 RAM_B_3 RAM_B_4 RAM_B_5 RAM_B_6 RAM_B_7 RAM_B_8 RAM_B_9
+  RAM_B_10 RAM_B_11 RAM_B_12 RAM_B_13 RAM_B_14 RAM_B_15 RAM_B_16 RAM_B_17
+  RAM_B_18 RAM_B_19 RAM_B_20 RAM_B_21 RAM_B_22 RAM_B_23 RAM_B_24 RAM_B_25
+  RAM_B_26 RAM_B_27 RAM_B_28 RAM_B_29 RAM_B_30 RAM_B_31 RAM_B_32 RAM_B_33
+  RAM_B_34 RAM_B_35 RAM_B_36 RAM_B_37 RAM_B_38 RAM_B_39 RAM_B_40 RAM_B_41
+  RAM_B_42 RAM_B_43 RAM_B_44 RAM_B_45 RAM_B_46 RAM_B_47 RAM_B_48 RAM_B_49
+  RAM_B_50 RAM_B_51 RAM_B_52 RAM_B_53 RAM_B_54 RAM_B_55 RAM_B_56 RAM_B_57
+  RAM_B_58 RAM_B_59 RAM_B_60 RAM_B_61 RAM_B_62 RAM_B_63 RAYA[0] RAYA[1]
+  RAYA[2] RAYA[3] RAYA[4] RAYA[5] RAYA[6] RAYA[7] RAYA[8] RAYB[0] RAYB[1]
+  RAYB[2] RAYB[3] RAYB[4] RAYB[5] RAYB[6] RAYB[7] RAYB[8] RET1N RET_0 RET_1
+  RE_0 RE_1 SEA SEB SIA_0 SIA_1 SIB_0 SIB_1 SOA[0] SOA[1] SOB[0] SOB[1]
+  TCAA[0] TCAA[1] TCAB[0] TCAB[1] TCENA TCENB TDA[0] TDA[1] TDA[2] TDA[3]
+  TDA[4] TDA[5] TDA[6] TDA[7] TDA[8] TDA[9] TDA[10] TDA[11] TDA[12] TDA[13]
+  TDA[14] TDA[15] TDA_0 TDA_1 TDA_2 TDA_3 TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9
+  TDA_10 TDA_11 TDA_12 TDA_13 TDA_14 TDA_15 TDA_16 TDA_17 TDA_18 TDA_19
+  TDA_20 TDA_21 TDA_22 TDA_23 TDA_24 TDA_25 TDA_26 TDA_27 TDA_28 TDA_29
+  TDA_30 TDA_31 TDA_32 TDA_33 TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39
+  TDA_40 TDA_41 TDA_42 TDA_43 TDA_44 TDA_45 TDA_46 TDA_47 TDB[0] TDB[1]
+  TDB[2] TDB[3] TDB[4] TDB[5] TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11]
+  TDB[12] TDB[13] TDB[14] TDB[15] TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6
+  TDB_7 TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17
+  TDB_18 TDB_19 TDB_20 TDB_21 TDB_22 TDB_23 TDB_24 TDB_25 TDB_26 TDB_27
+  TDB_28 TDB_29 TDB_30 TDB_31 TDB_32 TDB_33 TDB_34 TDB_35 TDB_36 TDB_37
+  TDB_38 TDB_39 TDB_40 TDB_41 TDB_42 TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TENA
+  TENB TGWENA TGWENB TRAA[0] TRAA[1] TRAA[2] TRAA[3] TRAA[4] TRAA[5] TRAB[0]
+  TRAB[1] TRAB[2] TRAB[3] TRAB[4] TRAB[5] VDDCE VDDPE WDATAO_A[0]_0
+  WDATAO_A[0]_1 WDATAO_A[0]_2 WDATAO_A[0]_3 WDATAO_A[0]_4 WDATAO_A[0]_5
+  WDATAO_A[0]_6 WDATAO_A[0]_7 WDATAO_A[0]_8 WDATAO_A[0]_9 WDATAO_A[0]_10
+  WDATAO_A[0]_11 WDATAO_A[0]_12 WDATAO_A[0]_13 WDATAO_A[0]_14 WDATAO_A[0]_15
+  WDATAO_A[0]_16 WDATAO_A[0]_17 WDATAO_A[0]_18 WDATAO_A[0]_19 WDATAO_A[0]_20
+  WDATAO_A[0]_21 WDATAO_A[0]_22 WDATAO_A[0]_23 WDATAO_A[0]_24 WDATAO_A[0]_25
+  WDATAO_A[0]_26 WDATAO_A[0]_27 WDATAO_A[0]_28 WDATAO_A[0]_29 WDATAO_A[0]_30
+  WDATAO_A[0]_31 WDATAO_A[0]_32 WDATAO_A[0]_33 WDATAO_A[0]_34 WDATAO_A[0]_35
+  WDATAO_A[0]_36 WDATAO_A[0]_37 WDATAO_A[0]_38 WDATAO_A[0]_39 WDATAO_A[0]_40
+  WDATAO_A[0]_41 WDATAO_A[0]_42 WDATAO_A[0]_43 WDATAO_A[0]_44 WDATAO_A[0]_45
+  WDATAO_A[0]_46 WDATAO_A[0]_47 WDATAO_A[0]_48 WDATAO_A[0]_49 WDATAO_A[0]_50
+  WDATAO_A[0]_51 WDATAO_A[0]_52 WDATAO_A[0]_53 WDATAO_A[0]_54 WDATAO_A[0]_55
+  WDATAO_A[0]_56 WDATAO_A[0]_57 WDATAO_A[0]_58 WDATAO_A[0]_59 WDATAO_A[0]_60
+  WDATAO_A[0]_61 WDATAO_A[0]_62 WDATAO_A[0]_63 WDATAO_B[0]_0 WDATAO_B[0]_1
+  WDATAO_B[0]_2 WDATAO_B[0]_3 WDATAO_B[0]_4 WDATAO_B[0]_5 WDATAO_B[0]_6
+  WDATAO_B[0]_7 WDATAO_B[0]_8 WDATAO_B[0]_9 WDATAO_B[0]_10 WDATAO_B[0]_11
+  WDATAO_B[0]_12 WDATAO_B[0]_13 WDATAO_B[0]_14 WDATAO_B[0]_15 WDATAO_B[0]_16
+  WDATAO_B[0]_17 WDATAO_B[0]_18 WDATAO_B[0]_19 WDATAO_B[0]_20 WDATAO_B[0]_21
+  WDATAO_B[0]_22 WDATAO_B[0]_23 WDATAO_B[0]_24 WDATAO_B[0]_25 WDATAO_B[0]_26
+  WDATAO_B[0]_27 WDATAO_B[0]_28 WDATAO_B[0]_29 WDATAO_B[0]_30 WDATAO_B[0]_31
+  WDATAO_B[0]_32 WDATAO_B[0]_33 WDATAO_B[0]_34 WDATAO_B[0]_35 WDATAO_B[0]_36
+  WDATAO_B[0]_37 WDATAO_B[0]_38 WDATAO_B[0]_39 WDATAO_B[0]_40 WDATAO_B[0]_41
+  WDATAO_B[0]_42 WDATAO_B[0]_43 WDATAO_B[0]_44 WDATAO_B[0]_45 WDATAO_B[0]_46
+  WDATAO_B[0]_47 WDATAO_B[0]_48 WDATAO_B[0]_49 WDATAO_B[0]_50 WDATAO_B[0]_51
+  WDATAO_B[0]_52 WDATAO_B[0]_53 WDATAO_B[0]_54 WDATAO_B[0]_55 WDATAO_B[0]_56
+  WDATAO_B[0]_57 WDATAO_B[0]_58 WDATAO_B[0]_59 WDATAO_B[0]_60 WDATAO_B[0]_61
+  WDATAO_B[0]_62 WDATAO_B[0]_63 WENYA[0] WENYA[1] WENYA[2] WENYA[3] WENYA[4]
+  WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11] WENYA[12]
+  WENYA[13] WENYA[14] WENYA[15] WENYA_0 WENYA_1 WENYA_2 WENYA_3 WENYA_4
+  WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9 WENYA_10 WENYA_11 WENYA_12 WENYA_13
+  WENYA_14 WENYA_15 WENYA_16 WENYA_17 WENYA_18 WENYA_19 WENYA_20 WENYA_21
+  WENYA_22 WENYA_23 WENYA_24 WENYA_25 WENYA_26 WENYA_27 WENYA_28 WENYA_29
+  WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35 WENYA_36 WENYA_37
+  WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43 WENYA_44 WENYA_45
+  WENYA_46 WENYA_47 WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5]
+  WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13]
+  WENYB[14] WENYB[15] WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6
+  WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13 WENYB_14
+  WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21 WENYB_22
+  WENYB_23 WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29 WENYB_30
+  WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37 WENYB_38
+  WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45 WENYB_46
+  WENYB_47 WE_0 WE_1 WR_MA_0 WR_MA_1 WTE_0 WTE_1
** SRAMdpw64d256IOARRAY64: 14198 flat devices **
XCNTRL_ROW ACTCLMP ACTCLMP_0 ACTCLMP_1 ACT_CTLM BDFTRAMBYP_A BDFTRAMBYP_B
+  PENSOA PENSOB PSOA[0] PSOA[1] PSOB[0] PSOB[1] BSEL_D_A BSEL_D_B BSEL_SI_A
+  BSEL_SI_B BSEL_TD_A BSEL_TD_B SOA[0] SOA[1] SOB[0] SOB[1] CAA[0] CAA[1]
+  CAA[2] CAB[0] CAB[1] CADDR_A[2] CADDR_A[3] CADDR_B[2] CADDR_B[3] CAYA[0]
+  CAYA[1] CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2] CAYB[3] CENA CENB CENYA
+  CENYB CLKA CLKB COLLDISN DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7]
+  DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14] DA[15] DA_0 DA_1 DA_2 DA_3
+  DA_4 DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16
+  DA_17 DA_18 DA_19 DA_20 DA_21 DA_22 DA_23 DA_24 DA_25 DA_26 DA_27 DA_28
+  DA_29 DA_30 DA_31 DA_32 DA_33 DA_34 DA_35 DA_36 DA_37 DA_38 DA_39 DA_40
+  DA_41 DA_42 DA_43 DA_44 DA_45 DA_46 DA_47 DB[0] DB[1] DB[2] DB[3] DB[4]
+  DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12] DB[13] DB[14] DB[15]
+  DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13
+  DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20 DB_21 DB_22 DB_23 DB_24 DB_25
+  DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 DB_32 DB_33 DB_34 DB_35 DB_36 DB_37
+  DB_38 DB_39 DB_40 DB_41 DB_42 DB_43 DB_44 DB_45 DB_46 DB_47 DFTRAMBYP
+  DFTRAMBYP_BUF_A DFTRAMBYP_BUF_B EMAA[0] EMAA[1] EMAA[2] EMAA_DEP2[0]
+  EMAA_DEP2[1] EMAA_DEP2[2] EMAB[0] EMAB[1] EMAB[2] EMAB_DEP2[0] EMAB_DEP2[1]
+  EMAB_DEP2[2] EMAWA[0] EMAWA[1] EMAWA_DEP2[0] EMAWA_DEP2[1] EMAWB[0]
+  EMAWB[1] EMAWB_DEP2[0] EMAWB_DEP2[1] GWENA GWENB GWENYA GWENYB LOG0_DBL
+  LOG0_PG NBNK_A NBNK_B NCADDR_A[0] NCADDR_A[1] NCADDR_B[0] NCADDR_B[1] NCE_A
+  NCE_B NCLK_CTL_A NCLK_CTL_B NRET_ACT_FT1_0 VDDCE NDFTCRE1 NDFTCRE2 NGWE_A
+  NGWE_B NGWE_WT_A NGWE_WT_B NHDR_WL_0 NHDR_WL_1 NRDT_0 NRDT_1 NRETNVT NRET_A
+  NRET_ACT_FT1_1 NRET_ACT_FT2 NRET_B NTE_A NTE_B NWRA_MA NWRB_MA NWTE_A
+  NWTE_B NXPDEC1[0]_0 NXPDEC1[1]_0 NXPDEC1[2]_0 NXPDEC1[3]_0 NXPDEC1[4]_0
+  NXPDEC1[5]_0 NXPDEC1[6]_0 NXPDEC1[7]_0 NXPDEC1[0]_1 NXPDEC1[1]_1
+  NXPDEC1[2]_1 NXPDEC1[3]_1 NXPDEC1[4]_1 NXPDEC1[5]_1 NXPDEC1[6]_1
+  NXPDEC1[7]_1 NXPDEC2[0]_0 NXPDEC2[1]_0 NXPDEC2[2]_0 NXPDEC2[3]_0
+  NXPDEC2[4]_0 NXPDEC2[5]_0 NXPDEC2[6]_0 NXPDEC2[7]_0 NXPDEC2[0]_1
+  NXPDEC2[1]_1 NXPDEC2[2]_1 NXPDEC2[3]_1 NXPDEC2[4]_1 NXPDEC2[5]_1
+  NXPDEC2[6]_1 NXPDEC2[7]_1 NXPDEC3[0]_0 NXPDEC3[1]_0 NXPDEC3[2]_0
+  NXPDEC3[3]_0 NXPDEC3[0]_1 NXPDEC3[1]_1 NXPDEC3[2]_1 NXPDEC3[3]_1 PENSOA_45
+  PSOA[1]_13 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  PENSOA_45 PSOA[1]_13 PENSOA_45 PSOA[1]_13 QA[0] QA[1] QA[2] QA[3] QA[4]
+  QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14] QA[15]
+  QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA_8 QA_9 QA_10 QA_11 QA_12 QA_13
+  QA_14 QA_15 QA_16 QA_17 QA_18 QA_19 QA_20 QA_21 QA_22 QA_23 QA_24 QA_25
+  QA_26 QA_27 QA_28 QA_29 QA_30 QA_31 QA_32 QA_33 QA_34 QA_35 QA_36 QA_37
+  QA_38 QA_39 QA_40 QA_41 QA_42 QA_43 QA_44 QA_45 QA_46 QA_47 QB[0] QB[1]
+  QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+  QB[14] QB[15] QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7 QB_8 QB_9 QB_10 QB_11
+  QB_12 QB_13 QB_14 QB_15 QB_16 QB_17 QB_18 QB_19 QB_20 QB_21 QB_22 QB_23
+  QB_24 QB_25 QB_26 QB_27 QB_28 QB_29 QB_30 QB_31 QB_32 QB_33 QB_34 QB_35
+  QB_36 QB_37 QB_38 QB_39 QB_40 QB_41 QB_42 QB_43 QB_44 QB_45 QB_46 QB_47
+  RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] RAB[0] RAB[1] RAB[2] RAB[3]
+  RAB[4] RAB[5] RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4] RAYA[5] RAYA[6]
+  RAYA[7] RAYA[8] RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4] RAYB[5] RAYB[6]
+  RAYB[7] RAYB[8] RET1N RET_0 RET_1 SEA SEB SIA_0 SIA_1 SIB_0 SIB_1 SOA[0]_49
+  SOA[1]_11 SOB[0]_47 SOB[1]_15 TCAA[0] TCAA[1] TCAB[0] TCAB[1] TCENA TCENB
+  TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5] TDA[6] TDA[7] TDA[8] TDA[9]
+  TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15] TDA_0 TDA_1 TDA_2 TDA_3
+  TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13 TDA_14
+  TDA_15 TDA_16 TDA_17 TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23 TDA_24
+  TDA_25 TDA_26 TDA_27 TDA_28 TDA_29 TDA_30 TDA_31 TDA_32 TDA_33 TDA_34
+  TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43 TDA_44
+  TDA_45 TDA_46 TDA_47 TDB[0] TDB[1] TDB[2] TDB[3] TDB[4] TDB[5] TDB[6]
+  TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12] TDB[13] TDB[14] TDB[15] TDB_0
+  TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7 TDB_8 TDB_9 TDB_10 TDB_11 TDB_12
+  TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18 TDB_19 TDB_20 TDB_21 TDB_22
+  TDB_23 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28 TDB_29 TDB_30 TDB_31 TDB_32
+  TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38 TDB_39 TDB_40 TDB_41 TDB_42
+  TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TENA TENB TGWENA TGWENB TRAA[0] TRAA[1]
+  TRAA[2] TRAA[3] TRAA[4] TRAA[5] TRAB[0] TRAB[1] TRAB[2] TRAB[3] TRAB[4]
+  TRAB[5] NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 VDDCE VDDPE
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 WENYA[0]
+  WENYA[1] WENYA[2] WENYA[3] WENYA[4] WENYA[5] WENYA[6] WENYA[7] WENYA[8]
+  WENYA[9] WENYA[10] WENYA[11] WENYA[12] WENYA[13] WENYA[14] WENYA[15]
+  WENYA_0 WENYA_1 WENYA_2 WENYA_3 WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8
+  WENYA_9 WENYA_10 WENYA_11 WENYA_12 WENYA_13 WENYA_14 WENYA_15 WENYA_16
+  WENYA_17 WENYA_18 WENYA_19 WENYA_20 WENYA_21 WENYA_22 WENYA_23 WENYA_24
+  WENYA_25 WENYA_26 WENYA_27 WENYA_28 WENYA_29 WENYA_30 WENYA_31 WENYA_32
+  WENYA_33 WENYA_34 WENYA_35 WENYA_36 WENYA_37 WENYA_38 WENYA_39 WENYA_40
+  WENYA_41 WENYA_42 WENYA_43 WENYA_44 WENYA_45 WENYA_46 WENYA_47 WENYB[0]
+  WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5] WENYB[6] WENYB[7] WENYB[8]
+  WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13] WENYB[14] WENYB[15]
+  WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6 WENYB_7 WENYB_8
+  WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13 WENYB_14 WENYB_15 WENYB_16
+  WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21 WENYB_22 WENYB_23 WENYB_24
+  WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29 WENYB_30 WENYB_31 WENYB_32
+  WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37 WENYB_38 WENYB_39 WENYB_40
+  WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45 WENYB_46 WENYB_47
+  SRAMdpw64d256CNTL1VR64M4
XDPTH_ROW ACTCLMP_0 ACTCLMP_1 BNK_0 BNK_1 CADDR[0]_0 CADDR[0]_1 CADDR[1]_0
+  CADDR[1]_1 CADDR_A[2] CADDR_B[2] CADDR_A[3] CADDR_B[3] CLKA CLKB CLK_GTP_0
+  CLK_GTP_1 DA_0 DA_1 DA_2 DA_3 DA_4 DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11
+  DA_12 DA_13 DA_14 DA_15 DA_16 DA_17 DA_18 DA_19 DA_20 DA_21 DA_22 DA_23
+  DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11]
+  DA[12] DA[13] DA[14] DA[15] DA_24 DA_25 DA_26 DA_27 DA_28 DA_29 DA_30 DA_31
+  DA_32 DA_33 DA_34 DA_35 DA_36 DA_37 DA_38 DA_39 DA_40 DA_41 DA_42 DA_43
+  DA_44 DA_45 DA_46 DA_47 DBL_0 DBL_1 DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7
+  DB_8 DB_9 DB_10 DB_11 DB_12 DB_13 DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20
+  DB_21 DB_22 DB_23 DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8]
+  DB[9] DB[10] DB[11] DB[12] DB[13] DB[14] DB[15] DB_24 DB_25 DB_26 DB_27
+  DB_28 DB_29 DB_30 DB_31 DB_32 DB_33 DB_34 DB_35 DB_36 DB_37 DB_38 DB_39
+  DB_40 DB_41 DB_42 DB_43 DB_44 DB_45 DB_46 DB_47 BDFTRAMBYP_A BDFTRAMBYP_B
+  DFTRAMBYP_BUF_A DFTRAMBYP_BUF_B EMAWA_DEP2[0] EMAWB_DEP2[0] EMAWA_DEP2[1]
+  EMAWB_DEP2[1] EMAA_DEP2[0] EMAB_DEP2[0] EMAA_DEP2[1] EMAB_DEP2[1]
+  EMAA_DEP2[2] EMAB_DEP2[2] PENSOA_45 PSOA[1]_13 LOG0_DBL LOG0_DBL LOG0_PG
+  NBNK_A NBNK_B NCADDR_A[0] NCADDR_B[0] NCADDR_A[1] NCADDR_B[1] NCE_A NCE_B
+  NCLK_CTL_A NCLK_CTL_B NDFTCRE1 NDFTCRE2 SEA SEB ACT_CTLM ACT_CTLM NC_VDDC_0
+  NC_VDDC_1 NC_VDDC_2 NC_VDDC_3 NC_VDDC_4 NC_VDDC_5 NC_VDDC_6 NC_VDDC_7
+  NC_VDDC_8 NC_VDDC_9 NC_VDDC_10 NC_VDDC_11 NC_VDDC_12 NC_VDDC_13 NC_VDDC_14
+  NC_VDDC_15 NC_VDDC_16 NC_VDDC_17 NC_VDDC_18 NC_VDDC_19 NC_VDDC_20
+  NC_VDDC_21 NC_VDDC_22 NC_VDDC_23 NC_VDDC_24 NC_VDDC_25 NC_VDDC_26
+  NC_VDDC_27 NC_VDDC_28 NC_VDDC_29 NC_VDDC_30 NC_VDDC_31 NC_VDDC_32
+  NC_VDDC_33 NC_VDDC_34 NC_VDDC_35 NC_VDDC_36 NC_VDDC_37 NC_VDDC_38
+  NC_VDDC_39 NC_VDDC_40 NC_VDDC_41 NC_VDDC_42 NC_VDDC_43 NC_VDDC_44
+  NC_VDDC_45 NC_VDDC_46 NC_VDDC_47 NC_VDDC_48 NC_VDDC_49 NC_VDDC_50
+  NC_VDDC_51 NC_VDDC_52 NC_VDDC_53 NC_VDDC_54 NC_VDDC_55 NC_VDDC_56
+  NC_VDDC_57 NC_VDDC_58 NC_VDDC_59 NC_VDDC_60 NC_VDDC_61 NC_VDDC_62
+  NC_VDDC_63 NDFTRAMBYPT_0 NDFTRAMBYPT_1 NGWE_A NGWE_B NGWE_WT_A NGWE_WT_B
+  NHDR_WL_0 NHDR_WL_1 NRDT_0 NRDT_1 NRET_A NRET_B NRET_ACT_FT1_1
+  NRET_ACT_FT1_0 NRET_ACT_FT2 NRET_ACT_FT1_0 NTE_A NTE_B NWGSEL_RED_A[0]_0
+  NWGSEL_RED_A[0]_1 NWGSEL_RED_A[0]_2 NWGSEL_RED_A[0]_3 NWGSEL_RED_A[0]_4
+  NWGSEL_RED_A[0]_5 NWGSEL_RED_A[0]_6 NWGSEL_RED_A[0]_7 NWGSEL_RED_A[0]_8
+  NWGSEL_RED_A[0]_9 NWGSEL_RED_A[0]_10 NWGSEL_RED_A[0]_11 NWGSEL_RED_A[0]_12
+  NWGSEL_RED_A[0]_13 NWGSEL_RED_A[0]_14 NWGSEL_RED_A[0]_15 NWGSEL_RED_A[0]_16
+  NWGSEL_RED_A[0]_17 NWGSEL_RED_A[0]_18 NWGSEL_RED_A[0]_19 NWGSEL_RED_A[0]_20
+  NWGSEL_RED_A[0]_21 NWGSEL_RED_A[0]_22 NWGSEL_RED_A[0]_23 NWGSEL_RED_A[0]_24
+  NWGSEL_RED_A[0]_25 NWGSEL_RED_A[0]_26 NWGSEL_RED_A[0]_27 NWGSEL_RED_A[0]_28
+  NWGSEL_RED_A[0]_29 NWGSEL_RED_A[0]_30 NWGSEL_RED_A[0]_31 NWGSEL_RED_A[0]_32
+  NWGSEL_RED_A[0]_33 NWGSEL_RED_A[0]_34 NWGSEL_RED_A[0]_35 NWGSEL_RED_A[0]_36
+  NWGSEL_RED_A[0]_37 NWGSEL_RED_A[0]_38 NWGSEL_RED_A[0]_39 NWGSEL_RED_A[0]_40
+  NWGSEL_RED_A[0]_41 NWGSEL_RED_A[0]_42 NWGSEL_RED_A[0]_43 NWGSEL_RED_A[0]_44
+  NWGSEL_RED_A[0]_45 NWGSEL_RED_A[0]_46 NWGSEL_RED_A[0]_47 NWGSEL_RED_A[0]_48
+  NWGSEL_RED_A[0]_49 NWGSEL_RED_A[0]_50 NWGSEL_RED_A[0]_51 NWGSEL_RED_A[0]_52
+  NWGSEL_RED_A[0]_53 NWGSEL_RED_A[0]_54 NWGSEL_RED_A[0]_55 NWGSEL_RED_A[0]_56
+  NWGSEL_RED_A[0]_57 NWGSEL_RED_A[0]_58 NWGSEL_RED_A[0]_59 NWGSEL_RED_A[0]_60
+  NWGSEL_RED_A[0]_61 NWGSEL_RED_A[0]_62 NWGSEL_RED_A[0]_63 NWGSEL_RED_B[0]_0
+  NWGSEL_RED_B[0]_1 NWGSEL_RED_B[0]_2 NWGSEL_RED_B[0]_3 NWGSEL_RED_B[0]_4
+  NWGSEL_RED_B[0]_5 NWGSEL_RED_B[0]_6 NWGSEL_RED_B[0]_7 NWGSEL_RED_B[0]_8
+  NWGSEL_RED_B[0]_9 NWGSEL_RED_B[0]_10 NWGSEL_RED_B[0]_11 NWGSEL_RED_B[0]_12
+  NWGSEL_RED_B[0]_13 NWGSEL_RED_B[0]_14 NWGSEL_RED_B[0]_15 NWGSEL_RED_B[0]_16
+  NWGSEL_RED_B[0]_17 NWGSEL_RED_B[0]_18 NWGSEL_RED_B[0]_19 NWGSEL_RED_B[0]_20
+  NWGSEL_RED_B[0]_21 NWGSEL_RED_B[0]_22 NWGSEL_RED_B[0]_23 NWGSEL_RED_B[0]_24
+  NWGSEL_RED_B[0]_25 NWGSEL_RED_B[0]_26 NWGSEL_RED_B[0]_27 NWGSEL_RED_B[0]_28
+  NWGSEL_RED_B[0]_29 NWGSEL_RED_B[0]_30 NWGSEL_RED_B[0]_31 NWGSEL_RED_B[0]_32
+  NWGSEL_RED_B[0]_33 NWGSEL_RED_B[0]_34 NWGSEL_RED_B[0]_35 NWGSEL_RED_B[0]_36
+  NWGSEL_RED_B[0]_37 NWGSEL_RED_B[0]_38 NWGSEL_RED_B[0]_39 NWGSEL_RED_B[0]_40
+  NWGSEL_RED_B[0]_41 NWGSEL_RED_B[0]_42 NWGSEL_RED_B[0]_43 NWGSEL_RED_B[0]_44
+  NWGSEL_RED_B[0]_45 NWGSEL_RED_B[0]_46 NWGSEL_RED_B[0]_47 NWGSEL_RED_B[0]_48
+  NWGSEL_RED_B[0]_49 NWGSEL_RED_B[0]_50 NWGSEL_RED_B[0]_51 NWGSEL_RED_B[0]_52
+  NWGSEL_RED_B[0]_53 NWGSEL_RED_B[0]_54 NWGSEL_RED_B[0]_55 NWGSEL_RED_B[0]_56
+  NWGSEL_RED_B[0]_57 NWGSEL_RED_B[0]_58 NWGSEL_RED_B[0]_59 NWGSEL_RED_B[0]_60
+  NWGSEL_RED_B[0]_61 NWGSEL_RED_B[0]_62 NWGSEL_RED_B[0]_63 NWRA_MA NWRB_MA
+  NWTE_A NWTE_B NXPDEC1[0]_0 NXPDEC1[0]_1 NXPDEC1[1]_0 NXPDEC1[1]_1
+  NXPDEC1[2]_0 NXPDEC1[2]_1 NXPDEC1[3]_0 NXPDEC1[3]_1 NXPDEC1[4]_0
+  NXPDEC1[4]_1 NXPDEC1[5]_0 NXPDEC1[5]_1 NXPDEC1[6]_0 NXPDEC1[6]_1
+  NXPDEC1[7]_0 NXPDEC1[7]_1 NXPDEC2[0]_0 NXPDEC2[0]_1 NXPDEC2[1]_0
+  NXPDEC2[1]_1 NXPDEC2[2]_0 NXPDEC2[2]_1 NXPDEC2[3]_0 NXPDEC2[3]_1
+  NXPDEC2[4]_0 NXPDEC2[4]_1 NXPDEC2[5]_0 NXPDEC2[5]_1 NXPDEC2[6]_0
+  NXPDEC2[6]_1 NXPDEC2[7]_0 NXPDEC2[7]_1 NXPDEC3[0]_0 NXPDEC3[0]_1
+  NXPDEC3[1]_0 NXPDEC3[1]_1 NXPDEC3[2]_0 NXPDEC3[2]_1 NXPDEC3[3]_0
+  NXPDEC3[3]_1 QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA_8 QA_9 QA_10 QA_11
+  QA_12 QA_13 QA_14 QA_15 QA_16 QA_17 QA_18 QA_19 QA_20 QA_21 QA_22 QA_23
+  QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11]
+  QA[12] QA[13] QA[14] QA[15] QA_24 QA_25 QA_26 QA_27 QA_28 QA_29 QA_30 QA_31
+  QA_32 QA_33 QA_34 QA_35 QA_36 QA_37 QA_38 QA_39 QA_40 QA_41 QA_42 QA_43
+  QA_44 QA_45 QA_46 QA_47 QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7 QB_8 QB_9
+  QB_10 QB_11 QB_12 QB_13 QB_14 QB_15 QB_16 QB_17 QB_18 QB_19 QB_20 QB_21
+  QB_22 QB_23 QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9]
+  QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB_24 QB_25 QB_26 QB_27 QB_28
+  QB_29 QB_30 QB_31 QB_32 QB_33 QB_34 QB_35 QB_36 QB_37 QB_38 QB_39 QB_40
+  QB_41 QB_42 QB_43 QB_44 QB_45 QB_46 QB_47 RAM_A_0 RAM_A_1 RAM_A_2 RAM_A_3
+  RAM_A_4 RAM_A_5 RAM_A_6 RAM_A_7 RAM_A_8 RAM_A_9 RAM_A_10 RAM_A_11 RAM_A_12
+  RAM_A_13 RAM_A_14 RAM_A_15 RAM_A_16 RAM_A_17 RAM_A_18 RAM_A_19 RAM_A_20
+  RAM_A_21 RAM_A_22 RAM_A_23 RAM_A_24 RAM_A_25 RAM_A_26 RAM_A_27 RAM_A_28
+  RAM_A_29 RAM_A_30 RAM_A_31 RAM_A_32 RAM_A_33 RAM_A_34 RAM_A_35 RAM_A_36
+  RAM_A_37 RAM_A_38 RAM_A_39 RAM_A_40 RAM_A_41 RAM_A_42 RAM_A_43 RAM_A_44
+  RAM_A_45 RAM_A_46 RAM_A_47 RAM_A_48 RAM_A_49 RAM_A_50 RAM_A_51 RAM_A_52
+  RAM_A_53 RAM_A_54 RAM_A_55 RAM_A_56 RAM_A_57 RAM_A_58 RAM_A_59 RAM_A_60
+  RAM_A_61 RAM_A_62 RAM_A_63 RAM_B_0 RAM_B_1 RAM_B_2 RAM_B_3 RAM_B_4 RAM_B_5
+  RAM_B_6 RAM_B_7 RAM_B_8 RAM_B_9 RAM_B_10 RAM_B_11 RAM_B_12 RAM_B_13
+  RAM_B_14 RAM_B_15 RAM_B_16 RAM_B_17 RAM_B_18 RAM_B_19 RAM_B_20 RAM_B_21
+  RAM_B_22 RAM_B_23 RAM_B_24 RAM_B_25 RAM_B_26 RAM_B_27 RAM_B_28 RAM_B_29
+  RAM_B_30 RAM_B_31 RAM_B_32 RAM_B_33 RAM_B_34 RAM_B_35 RAM_B_36 RAM_B_37
+  RAM_B_38 RAM_B_39 RAM_B_40 RAM_B_41 RAM_B_42 RAM_B_43 RAM_B_44 RAM_B_45
+  RAM_B_46 RAM_B_47 RAM_B_48 RAM_B_49 RAM_B_50 RAM_B_51 RAM_B_52 RAM_B_53
+  RAM_B_54 RAM_B_55 RAM_B_56 RAM_B_57 RAM_B_58 RAM_B_59 RAM_B_60 RAM_B_61
+  RAM_B_62 RAM_B_63 RET_0 RET_1 RE_0 RE_1 BSEL_D_A BSEL_D_B BSEL_SI_A
+  BSEL_SI_B BSEL_TD_A BSEL_TD_B SIA_0 SIA_1 SIB_0 SIB_1 SOA[0]_49 SOA[1]_11
+  SOB[0]_47 SOB[1]_15 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 TDA_0 TDA_1 TDA_2 TDA_3 TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9
+  TDA_10 TDA_11 TDA_12 TDA_13 TDA_14 TDA_15 TDA_16 TDA_17 TDA_18 TDA_19
+  TDA_20 TDA_21 TDA_22 TDA_23 TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5]
+  TDA[6] TDA[7] TDA[8] TDA[9] TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15]
+  TDA_24 TDA_25 TDA_26 TDA_27 TDA_28 TDA_29 TDA_30 TDA_31 TDA_32 TDA_33
+  TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43
+  TDA_44 TDA_45 TDA_46 TDA_47 TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7
+  TDB_8 TDB_9 TDB_10 TDB_11 TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18
+  TDB_19 TDB_20 TDB_21 TDB_22 TDB_23 TDB[0] TDB[1] TDB[2] TDB[3] TDB[4]
+  TDB[5] TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12] TDB[13] TDB[14]
+  TDB[15] TDB_24 TDB_25 TDB_26 TDB_27 TDB_28 TDB_29 TDB_30 TDB_31 TDB_32
+  TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38 TDB_39 TDB_40 TDB_41 TDB_42
+  TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 VDDCE VDDCE VDDPE NRET_ACT_FT1_0
+  WDATAO_A[0]_0 WDATAO_A[0]_1 WDATAO_A[0]_2 WDATAO_A[0]_3 WDATAO_A[0]_4
+  WDATAO_A[0]_5 WDATAO_A[0]_6 WDATAO_A[0]_7 WDATAO_A[0]_8 WDATAO_A[0]_9
+  WDATAO_A[0]_10 WDATAO_A[0]_11 WDATAO_A[0]_12 WDATAO_A[0]_13 WDATAO_A[0]_14
+  WDATAO_A[0]_15 WDATAO_A[0]_16 WDATAO_A[0]_17 WDATAO_A[0]_18 WDATAO_A[0]_19
+  WDATAO_A[0]_20 WDATAO_A[0]_21 WDATAO_A[0]_22 WDATAO_A[0]_23 WDATAO_A[0]_24
+  WDATAO_A[0]_25 WDATAO_A[0]_26 WDATAO_A[0]_27 WDATAO_A[0]_28 WDATAO_A[0]_29
+  WDATAO_A[0]_30 WDATAO_A[0]_31 WDATAO_A[0]_32 WDATAO_A[0]_33 WDATAO_A[0]_34
+  WDATAO_A[0]_35 WDATAO_A[0]_36 WDATAO_A[0]_37 WDATAO_A[0]_38 WDATAO_A[0]_39
+  WDATAO_A[0]_40 WDATAO_A[0]_41 WDATAO_A[0]_42 WDATAO_A[0]_43 WDATAO_A[0]_44
+  WDATAO_A[0]_45 WDATAO_A[0]_46 WDATAO_A[0]_47 WDATAO_A[0]_48 WDATAO_A[0]_49
+  WDATAO_A[0]_50 WDATAO_A[0]_51 WDATAO_A[0]_52 WDATAO_A[0]_53 WDATAO_A[0]_54
+  WDATAO_A[0]_55 WDATAO_A[0]_56 WDATAO_A[0]_57 WDATAO_A[0]_58 WDATAO_A[0]_59
+  WDATAO_A[0]_60 WDATAO_A[0]_61 WDATAO_A[0]_62 WDATAO_A[0]_63 WDATAO_B[0]_0
+  WDATAO_B[0]_1 WDATAO_B[0]_2 WDATAO_B[0]_3 WDATAO_B[0]_4 WDATAO_B[0]_5
+  WDATAO_B[0]_6 WDATAO_B[0]_7 WDATAO_B[0]_8 WDATAO_B[0]_9 WDATAO_B[0]_10
+  WDATAO_B[0]_11 WDATAO_B[0]_12 WDATAO_B[0]_13 WDATAO_B[0]_14 WDATAO_B[0]_15
+  WDATAO_B[0]_16 WDATAO_B[0]_17 WDATAO_B[0]_18 WDATAO_B[0]_19 WDATAO_B[0]_20
+  WDATAO_B[0]_21 WDATAO_B[0]_22 WDATAO_B[0]_23 WDATAO_B[0]_24 WDATAO_B[0]_25
+  WDATAO_B[0]_26 WDATAO_B[0]_27 WDATAO_B[0]_28 WDATAO_B[0]_29 WDATAO_B[0]_30
+  WDATAO_B[0]_31 WDATAO_B[0]_32 WDATAO_B[0]_33 WDATAO_B[0]_34 WDATAO_B[0]_35
+  WDATAO_B[0]_36 WDATAO_B[0]_37 WDATAO_B[0]_38 WDATAO_B[0]_39 WDATAO_B[0]_40
+  WDATAO_B[0]_41 WDATAO_B[0]_42 WDATAO_B[0]_43 WDATAO_B[0]_44 WDATAO_B[0]_45
+  WDATAO_B[0]_46 WDATAO_B[0]_47 WDATAO_B[0]_48 WDATAO_B[0]_49 WDATAO_B[0]_50
+  WDATAO_B[0]_51 WDATAO_B[0]_52 WDATAO_B[0]_53 WDATAO_B[0]_54 WDATAO_B[0]_55
+  WDATAO_B[0]_56 WDATAO_B[0]_57 WDATAO_B[0]_58 WDATAO_B[0]_59 WDATAO_B[0]_60
+  WDATAO_B[0]_61 WDATAO_B[0]_62 WDATAO_B[0]_63 WENYA_0 WENYA_1 WENYA_2
+  WENYA_3 WENYA_4 WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9 WENYA_10 WENYA_11
+  WENYA_12 WENYA_13 WENYA_14 WENYA_15 WENYA_16 WENYA_17 WENYA_18 WENYA_19
+  WENYA_20 WENYA_21 WENYA_22 WENYA_23 WENYA[0] WENYA[1] WENYA[2] WENYA[3]
+  WENYA[4] WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11]
+  WENYA[12] WENYA[13] WENYA[14] WENYA[15] WENYA_24 WENYA_25 WENYA_26 WENYA_27
+  WENYA_28 WENYA_29 WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35
+  WENYA_36 WENYA_37 WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43
+  WENYA_44 WENYA_45 WENYA_46 WENYA_47 WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4
+  WENYB_5 WENYB_6 WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13
+  WENYB_14 WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21
+  WENYB_22 WENYB_23 WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5]
+  WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13]
+  WENYB[14] WENYB[15] WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29
+  WENYB_30 WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37
+  WENYB_38 WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45
+  WENYB_46 WENYB_47 WE_0 WE_1 WR_MA_0 WR_MA_1 WTE_0 WTE_1
+  SRAMdpw64d256DPTH1VR64M4
XPIN_ROW CAA[0] CAA[1] CAA[2] CAA[2] CAB[0] CAB[1] CAA[2] CAA[2] CAYA[0]
+  CAYA[1] CAYA[2] CAYA[3] CAYB[0] CAYB[1] CAYB[2] CAYB[3] CENA CENB CENYA
+  CENYB CLKA CLKB COLLDISN DA[0] DA[1] DA[2] DA[3] DA[4] DA[5] DA[6] DA[7]
+  DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14] DA[15] DA_0 DA_1 DA_2 DA_3
+  DA_4 DA_5 DA_6 DA_7 DA_8 DA_9 DA_10 DA_11 DA_12 DA_13 DA_14 DA_15 DA_16
+  DA_17 DA_18 DA_19 DA_20 DA_21 DA_22 DA_23 DA_24 DA_25 DA_26 DA_27 DA_28
+  DA_29 DA_30 DA_31 DA_32 DA_33 DA_34 DA_35 DA_36 DA_37 DA_38 DA_39 DA_40
+  DA_41 DA_42 DA_43 DA_44 DA_45 DA_46 DA_47 DB[0] DB[1] DB[2] DB[3] DB[4]
+  DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12] DB[13] DB[14] DB[15]
+  DB_0 DB_1 DB_2 DB_3 DB_4 DB_5 DB_6 DB_7 DB_8 DB_9 DB_10 DB_11 DB_12 DB_13
+  DB_14 DB_15 DB_16 DB_17 DB_18 DB_19 DB_20 DB_21 DB_22 DB_23 DB_24 DB_25
+  DB_26 DB_27 DB_28 DB_29 DB_30 DB_31 DB_32 DB_33 DB_34 DB_35 DB_36 DB_37
+  DB_38 DB_39 DB_40 DB_41 DB_42 DB_43 DB_44 DB_45 DB_46 DB_47 DFTRAMBYP
+  EMAA[0] EMAA[1] EMAA[2] EMAB[0] EMAB[1] EMAB[2] EMAWA[0] EMAWA[1] EMAWB[0]
+  EMAWB[1] GWENA GWENB GWENYA GWENYB ACTCLMP ACT_CTLM ACT_CTLM ACT_CTLM
+  NRET_ACT_FT1_0 NRETNVT ACT_CTLM NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 PENSOA PENSOB NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 PSOA[0] PSOA[1] PSOB[0] PSOB[1] QA[0] QA[1]
+  QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10] QA[11] QA[12] QA[13]
+  QA[14] QA[15] QA_0 QA_1 QA_2 QA_3 QA_4 QA_5 QA_6 QA_7 QA_8 QA_9 QA_10 QA_11
+  QA_12 QA_13 QA_14 QA_15 QA_16 QA_17 QA_18 QA_19 QA_20 QA_21 QA_22 QA_23
+  QA_24 QA_25 QA_26 QA_27 QA_28 QA_29 QA_30 QA_31 QA_32 QA_33 QA_34 QA_35
+  QA_36 QA_37 QA_38 QA_39 QA_40 QA_41 QA_42 QA_43 QA_44 QA_45 QA_46 QA_47
+  QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11]
+  QB[12] QB[13] QB[14] QB[15] QB_0 QB_1 QB_2 QB_3 QB_4 QB_5 QB_6 QB_7 QB_8
+  QB_9 QB_10 QB_11 QB_12 QB_13 QB_14 QB_15 QB_16 QB_17 QB_18 QB_19 QB_20
+  QB_21 QB_22 QB_23 QB_24 QB_25 QB_26 QB_27 QB_28 QB_29 QB_30 QB_31 QB_32
+  QB_33 QB_34 QB_35 QB_36 QB_37 QB_38 QB_39 QB_40 QB_41 QB_42 QB_43 QB_44
+  QB_45 QB_46 QB_47 RAA[0] RAA[1] RAA[2] RAA[3] RAA[4] RAA[5] CAA[2] CAA[2]
+  CAA[2] RAB[0] RAB[1] RAB[2] RAB[3] RAB[4] RAB[5] CAA[2] CAA[2] CAA[2]
+  RAYA[0] RAYA[1] RAYA[2] RAYA[3] RAYA[4] RAYA[5] RAYA[6] RAYA[7] RAYA[8]
+  RAYB[0] RAYB[1] RAYB[2] RAYB[3] RAYB[4] RAYB[5] RAYB[6] RAYB[7] RAYB[8]
+  CAA[2] CAA[2] RET1N VDDCE SEA SEB SIA_0 SIA_1 SIB_0 SIB_1 SOA[0] SOA[1]
+  SOB[0] SOB[1] TCAA[0] TCAA[1] CAA[2] CAA[2] TCAB[0] TCAB[1] CAA[2] CAA[2]
+  TCENA TCENB TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5] TDA[6] TDA[7] TDA[8]
+  TDA[9] TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15] TDA_0 TDA_1 TDA_2
+  TDA_3 TDA_4 TDA_5 TDA_6 TDA_7 TDA_8 TDA_9 TDA_10 TDA_11 TDA_12 TDA_13
+  TDA_14 TDA_15 TDA_16 TDA_17 TDA_18 TDA_19 TDA_20 TDA_21 TDA_22 TDA_23
+  TDA_24 TDA_25 TDA_26 TDA_27 TDA_28 TDA_29 TDA_30 TDA_31 TDA_32 TDA_33
+  TDA_34 TDA_35 TDA_36 TDA_37 TDA_38 TDA_39 TDA_40 TDA_41 TDA_42 TDA_43
+  TDA_44 TDA_45 TDA_46 TDA_47 TDB[0] TDB[1] TDB[2] TDB[3] TDB[4] TDB[5]
+  TDB[6] TDB[7] TDB[8] TDB[9] TDB[10] TDB[11] TDB[12] TDB[13] TDB[14] TDB[15]
+  TDB_0 TDB_1 TDB_2 TDB_3 TDB_4 TDB_5 TDB_6 TDB_7 TDB_8 TDB_9 TDB_10 TDB_11
+  TDB_12 TDB_13 TDB_14 TDB_15 TDB_16 TDB_17 TDB_18 TDB_19 TDB_20 TDB_21
+  TDB_22 TDB_23 TDB_24 TDB_25 TDB_26 TDB_27 TDB_28 TDB_29 TDB_30 TDB_31
+  TDB_32 TDB_33 TDB_34 TDB_35 TDB_36 TDB_37 TDB_38 TDB_39 TDB_40 TDB_41
+  TDB_42 TDB_43 TDB_44 TDB_45 TDB_46 TDB_47 TENA TENB TGWENA TGWENB
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 TRAA[0] TRAA[1] TRAA[2] TRAA[3] TRAA[4]
+  TRAA[5] CAA[2] CAA[2] CAA[2] TRAB[0] TRAB[1] TRAB[2] TRAB[3] TRAB[4]
+  TRAB[5] CAA[2] CAA[2] CAA[2] NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDPE VDDCE VDDCE VDDCE VDDPE NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0 NRET_ACT_FT1_0
+  NRET_ACT_FT1_0 NRET_ACT_FT1_0 WENYA[0] WENYA[1] WENYA[2] WENYA[3] WENYA[4]
+  WENYA[5] WENYA[6] WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11] WENYA[12]
+  WENYA[13] WENYA[14] WENYA[15] WENYA_0 WENYA_1 WENYA_2 WENYA_3 WENYA_4
+  WENYA_5 WENYA_6 WENYA_7 WENYA_8 WENYA_9 WENYA_10 WENYA_11 WENYA_12 WENYA_13
+  WENYA_14 WENYA_15 WENYA_16 WENYA_17 WENYA_18 WENYA_19 WENYA_20 WENYA_21
+  WENYA_22 WENYA_23 WENYA_24 WENYA_25 WENYA_26 WENYA_27 WENYA_28 WENYA_29
+  WENYA_30 WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35 WENYA_36 WENYA_37
+  WENYA_38 WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43 WENYA_44 WENYA_45
+  WENYA_46 WENYA_47 WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5]
+  WENYB[6] WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13]
+  WENYB[14] WENYB[15] WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6
+  WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13 WENYB_14
+  WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21 WENYB_22
+  WENYB_23 WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29 WENYB_30
+  WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37 WENYB_38
+  WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45 WENYB_46
+  WENYB_47 SRAMdpw64d256PIN1VR64M4
.ENDS SRAMdpw64d256IOARRAY64
****
.SUBCKT SRAMdpw64d256 VDDCE VDDPE VSSE CENYA WENYA AYA[7] AYA[6] AYA[5] AYA[4]
+  AYA[3] AYA[2] AYA[1] AYA[0] CENYB WENYB AYB[7] AYB[6] AYB[5] AYB[4] AYB[3]
+  AYB[2] AYB[1] AYB[0] QA[63] QA[62] QA[61] QA[60] QA[59] QA[58] QA[57]
+  QA[56] QA[55] QA[54] QA[53] QA[52] QA[51] QA[50] QA[49] QA[48] QA[47]
+  QA[46] QA[45] QA[44] QA[43] QA[42] QA[41] QA[40] QA[39] QA[38] QA[37]
+  QA[36] QA[35] QA[34] QA[33] QA[32] QA[31] QA[30] QA[29] QA[28] QA[27]
+  QA[26] QA[25] QA[24] QA[23] QA[22] QA[21] QA[20] QA[19] QA[18] QA[17]
+  QA[16] QA[15] QA[14] QA[13] QA[12] QA[11] QA[10] QA[9] QA[8] QA[7] QA[6]
+  QA[5] QA[4] QA[3] QA[2] QA[1] QA[0] QB[63] QB[62] QB[61] QB[60] QB[59]
+  QB[58] QB[57] QB[56] QB[55] QB[54] QB[53] QB[52] QB[51] QB[50] QB[49]
+  QB[48] QB[47] QB[46] QB[45] QB[44] QB[43] QB[42] QB[41] QB[40] QB[39]
+  QB[38] QB[37] QB[36] QB[35] QB[34] QB[33] QB[32] QB[31] QB[30] QB[29]
+  QB[28] QB[27] QB[26] QB[25] QB[24] QB[23] QB[22] QB[21] QB[20] QB[19]
+  QB[18] QB[17] QB[16] QB[15] QB[14] QB[13] QB[12] QB[11] QB[10] QB[9] QB[8]
+  QB[7] QB[6] QB[5] QB[4] QB[3] QB[2] QB[1] QB[0] SOA[1] SOA[0] SOB[1] SOB[0]
+  CLKA CENA WENA AA[7] AA[6] AA[5] AA[4] AA[3] AA[2] AA[1] AA[0] DA[63]
+  DA[62] DA[61] DA[60] DA[59] DA[58] DA[57] DA[56] DA[55] DA[54] DA[53]
+  DA[52] DA[51] DA[50] DA[49] DA[48] DA[47] DA[46] DA[45] DA[44] DA[43]
+  DA[42] DA[41] DA[40] DA[39] DA[38] DA[37] DA[36] DA[35] DA[34] DA[33]
+  DA[32] DA[31] DA[30] DA[29] DA[28] DA[27] DA[26] DA[25] DA[24] DA[23]
+  DA[22] DA[21] DA[20] DA[19] DA[18] DA[17] DA[16] DA[15] DA[14] DA[13]
+  DA[12] DA[11] DA[10] DA[9] DA[8] DA[7] DA[6] DA[5] DA[4] DA[3] DA[2] DA[1]
+  DA[0] CLKB CENB WENB AB[7] AB[6] AB[5] AB[4] AB[3] AB[2] AB[1] AB[0] DB[63]
+  DB[62] DB[61] DB[60] DB[59] DB[58] DB[57] DB[56] DB[55] DB[54] DB[53]
+  DB[52] DB[51] DB[50] DB[49] DB[48] DB[47] DB[46] DB[45] DB[44] DB[43]
+  DB[42] DB[41] DB[40] DB[39] DB[38] DB[37] DB[36] DB[35] DB[34] DB[33]
+  DB[32] DB[31] DB[30] DB[29] DB[28] DB[27] DB[26] DB[25] DB[24] DB[23]
+  DB[22] DB[21] DB[20] DB[19] DB[18] DB[17] DB[16] DB[15] DB[14] DB[13]
+  DB[12] DB[11] DB[10] DB[9] DB[8] DB[7] DB[6] DB[5] DB[4] DB[3] DB[2] DB[1]
+  DB[0] EMAA[2] EMAA[1] EMAA[0] EMAWA[1] EMAWA[0] EMAB[2] EMAB[1] EMAB[0]
+  EMAWB[1] EMAWB[0] TENA TCENA TWENA TAA[7] TAA[6] TAA[5] TAA[4] TAA[3]
+  TAA[2] TAA[1] TAA[0] TDA[63] TDA[62] TDA[61] TDA[60] TDA[59] TDA[58]
+  TDA[57] TDA[56] TDA[55] TDA[54] TDA[53] TDA[52] TDA[51] TDA[50] TDA[49]
+  TDA[48] TDA[47] TDA[46] TDA[45] TDA[44] TDA[43] TDA[42] TDA[41] TDA[40]
+  TDA[39] TDA[38] TDA[37] TDA[36] TDA[35] TDA[34] TDA[33] TDA[32] TDA[31]
+  TDA[30] TDA[29] TDA[28] TDA[27] TDA[26] TDA[25] TDA[24] TDA[23] TDA[22]
+  TDA[21] TDA[20] TDA[19] TDA[18] TDA[17] TDA[16] TDA[15] TDA[14] TDA[13]
+  TDA[12] TDA[11] TDA[10] TDA[9] TDA[8] TDA[7] TDA[6] TDA[5] TDA[4] TDA[3]
+  TDA[2] TDA[1] TDA[0] TENB TCENB TWENB TAB[7] TAB[6] TAB[5] TAB[4] TAB[3]
+  TAB[2] TAB[1] TAB[0] TDB[63] TDB[62] TDB[61] TDB[60] TDB[59] TDB[58]
+  TDB[57] TDB[56] TDB[55] TDB[54] TDB[53] TDB[52] TDB[51] TDB[50] TDB[49]
+  TDB[48] TDB[47] TDB[46] TDB[45] TDB[44] TDB[43] TDB[42] TDB[41] TDB[40]
+  TDB[39] TDB[38] TDB[37] TDB[36] TDB[35] TDB[34] TDB[33] TDB[32] TDB[31]
+  TDB[30] TDB[29] TDB[28] TDB[27] TDB[26] TDB[25] TDB[24] TDB[23] TDB[22]
+  TDB[21] TDB[20] TDB[19] TDB[18] TDB[17] TDB[16] TDB[15] TDB[14] TDB[13]
+  TDB[12] TDB[11] TDB[10] TDB[9] TDB[8] TDB[7] TDB[6] TDB[5] TDB[4] TDB[3]
+  TDB[2] TDB[1] TDB[0] RET1N SIA[1] SIA[0] SEA DFTRAMBYP SIB[1] SIB[0] SEB
+  COLLDISN
** SRAMdpw64d256: 173417 flat devices **
XCCARRAY ACTCLMP_A ACTCLMP_B ADDR_A[0] ADDR_A[1] ADDR_B[0] ADDR_B[1] BNK_A
+  BNK_B CLK_A CLK_B DATAIN_A_0 DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4
+  DATAIN_A_5 DATAIN_A_6 DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10
+  DATAIN_A_11 DATAIN_A_12 DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16
+  DATAIN_A_17 DATAIN_A_18 DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22
+  DATAIN_A_23 DATAIN_A_24 DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28
+  DATAIN_A_29 DATAIN_A_30 DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34
+  DATAIN_A_35 DATAIN_A_36 DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40
+  DATAIN_A_41 DATAIN_A_42 DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46
+  DATAIN_A_47 DATAIN_A_48 DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52
+  DATAIN_A_53 DATAIN_A_54 DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58
+  DATAIN_A_59 DATAIN_A_60 DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0
+  DATAIN_B_1 DATAIN_B_2 DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6
+  DATAIN_B_7 DATAIN_B_8 DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12
+  DATAIN_B_13 DATAIN_B_14 DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18
+  DATAIN_B_19 DATAIN_B_20 DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24
+  DATAIN_B_25 DATAIN_B_26 DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30
+  DATAIN_B_31 DATAIN_B_32 DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36
+  DATAIN_B_37 DATAIN_B_38 DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42
+  DATAIN_B_43 DATAIN_B_44 DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48
+  DATAIN_B_49 DATAIN_B_50 DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54
+  DATAIN_B_55 DATAIN_B_56 DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60
+  DATAIN_B_61 DATAIN_B_62 DATAIN_B_63 DBL_A DBL_B GDL_A_0 GDL_A_1 GDL_A_2
+  GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10 GDL_A_11
+  GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18 GDL_A_19
+  GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26 GDL_A_27
+  GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34 GDL_A_35
+  GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42 GDL_A_43
+  GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50 GDL_A_51
+  GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58 GDL_A_59
+  GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2 GDL_B_3 GDL_B_4
+  GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11 GDL_B_12 GDL_B_13
+  GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19 GDL_B_20 GDL_B_21
+  GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27 GDL_B_28 GDL_B_29
+  GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35 GDL_B_36 GDL_B_37
+  GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43 GDL_B_44 GDL_B_45
+  GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51 GDL_B_52 GDL_B_53
+  GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59 GDL_B_60 GDL_B_61
+  GDL_B_62 GDL_B_63 LOG0_DBL_B LOG0_DBL_B NACT VSSE NDFTRAMBYP_A NDFTRAMBYP_B
+  NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B VSSE NRETNVT NWGSEL_A_0 NWGSEL_A_1
+  NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7
+  NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13
+  NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19
+  NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25
+  NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31
+  NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37
+  NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43
+  NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49
+  NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55
+  NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61
+  NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3
+  NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9
+  NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15
+  NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21
+  NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27
+  NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33
+  NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39
+  NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45
+  NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51
+  NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57
+  NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63
+  NXPDEC1_A[0] NXPDEC1_A[1] NXPDEC1_A[2] NXPDEC1_A[3] NXPDEC1_A[4]
+  NXPDEC1_A[5] NXPDEC1_A[6] NXPDEC1_A[7] NXPDEC1_B[0] NXPDEC1_B[1]
+  NXPDEC1_B[2] NXPDEC1_B[3] NXPDEC1_B[4] NXPDEC1_B[5] NXPDEC1_B[6]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_A[1] NXPDEC2_A[2] NXPDEC2_A[3]
+  NXPDEC2_A[4] NXPDEC2_A[5] NXPDEC2_A[6] NXPDEC2_A[7] NXPDEC2_B[0]
+  NXPDEC2_B[1] NXPDEC2_B[2] NXPDEC2_B[3] NXPDEC2_B[4] NXPDEC2_B[5]
+  NXPDEC2_B[6] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_A[1] NXPDEC3_A[2]
+  NXPDEC3_A[3] NXPDEC3_B[0] NXPDEC3_B[1] NXPDEC3_B[2] NXPDEC3_B[3] RETA[1]
+  RETA[1] RETB[0] RETB[0] RE_A RE_B VDDCE VDDPE VSSE WE_A WE_B WRA_MA WRB_MA
+  WTE_A WTE_B SRAMdpw64d256ARRAYWLOGIC_256_64
XIOARRAY ACTCLMP_A ACTCLMP_B BNK_A BNK_B AA[0] AA[1] CAA[2] AB[0] AB[1]
+  ADDR_A[0] ADDR_B[0] ADDR_A[1] ADDR_B[1] AYA[0] AYA[1] CAYA[2] CAYA[3]
+  AYB[0] AYB[1] CAYB[2] CAYB[3] CENA CENB CENYA CENYB CLKA CLKB CLK_A CLK_B
+  COLLDISN DA[24] DA[25] DA[26] DA[27] DA[28] DA[29] DA[30] DA[31] DA[32]
+  DA[33] DA[34] DA[35] DA[36] DA[37] DA[38] DA[39] DA[0] DA[1] DA[2] DA[3]
+  DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14]
+  DA[15] DA[16] DA[17] DA[18] DA[19] DA[20] DA[21] DA[22] DA[23] DA[40]
+  DA[41] DA[42] DA[43] DA[44] DA[45] DA[46] DA[47] DA[48] DA[49] DA[50]
+  DA[51] DA[52] DA[53] DA[54] DA[55] DA[56] DA[57] DA[58] DA[59] DA[60]
+  DA[61] DA[62] DA[63] DBL_A DBL_B DB[24] DB[25] DB[26] DB[27] DB[28] DB[29]
+  DB[30] DB[31] DB[32] DB[33] DB[34] DB[35] DB[36] DB[37] DB[38] DB[39] DB[0]
+  DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10] DB[11] DB[12]
+  DB[13] DB[14] DB[15] DB[16] DB[17] DB[18] DB[19] DB[20] DB[21] DB[22]
+  DB[23] DB[40] DB[41] DB[42] DB[43] DB[44] DB[45] DB[46] DB[47] DB[48]
+  DB[49] DB[50] DB[51] DB[52] DB[53] DB[54] DB[55] DB[56] DB[57] DB[58]
+  DB[59] DB[60] DB[61] DB[62] DB[63] DFTRAMBYP EMAA[0] EMAA[1] EMAA[2]
+  EMAB[0] EMAB[1] EMAB[2] EMAWA[0] EMAWA[1] EMAWB[0] EMAWB[1] WENA WENB WENYA
+  WENYB LOG0_DBL_B VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE
+  VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE VDDCE NDFTRAMBYP_A NDFTRAMBYP_B
+  NHDR_WL_A NHDR_WL_B NRDT_A NRDT_B VSSE NRETNVT NACT NWGSEL_A_0 NWGSEL_A_1
+  NWGSEL_A_2 NWGSEL_A_3 NWGSEL_A_4 NWGSEL_A_5 NWGSEL_A_6 NWGSEL_A_7
+  NWGSEL_A_8 NWGSEL_A_9 NWGSEL_A_10 NWGSEL_A_11 NWGSEL_A_12 NWGSEL_A_13
+  NWGSEL_A_14 NWGSEL_A_15 NWGSEL_A_16 NWGSEL_A_17 NWGSEL_A_18 NWGSEL_A_19
+  NWGSEL_A_20 NWGSEL_A_21 NWGSEL_A_22 NWGSEL_A_23 NWGSEL_A_24 NWGSEL_A_25
+  NWGSEL_A_26 NWGSEL_A_27 NWGSEL_A_28 NWGSEL_A_29 NWGSEL_A_30 NWGSEL_A_31
+  NWGSEL_A_32 NWGSEL_A_33 NWGSEL_A_34 NWGSEL_A_35 NWGSEL_A_36 NWGSEL_A_37
+  NWGSEL_A_38 NWGSEL_A_39 NWGSEL_A_40 NWGSEL_A_41 NWGSEL_A_42 NWGSEL_A_43
+  NWGSEL_A_44 NWGSEL_A_45 NWGSEL_A_46 NWGSEL_A_47 NWGSEL_A_48 NWGSEL_A_49
+  NWGSEL_A_50 NWGSEL_A_51 NWGSEL_A_52 NWGSEL_A_53 NWGSEL_A_54 NWGSEL_A_55
+  NWGSEL_A_56 NWGSEL_A_57 NWGSEL_A_58 NWGSEL_A_59 NWGSEL_A_60 NWGSEL_A_61
+  NWGSEL_A_62 NWGSEL_A_63 NWGSEL_B_0 NWGSEL_B_1 NWGSEL_B_2 NWGSEL_B_3
+  NWGSEL_B_4 NWGSEL_B_5 NWGSEL_B_6 NWGSEL_B_7 NWGSEL_B_8 NWGSEL_B_9
+  NWGSEL_B_10 NWGSEL_B_11 NWGSEL_B_12 NWGSEL_B_13 NWGSEL_B_14 NWGSEL_B_15
+  NWGSEL_B_16 NWGSEL_B_17 NWGSEL_B_18 NWGSEL_B_19 NWGSEL_B_20 NWGSEL_B_21
+  NWGSEL_B_22 NWGSEL_B_23 NWGSEL_B_24 NWGSEL_B_25 NWGSEL_B_26 NWGSEL_B_27
+  NWGSEL_B_28 NWGSEL_B_29 NWGSEL_B_30 NWGSEL_B_31 NWGSEL_B_32 NWGSEL_B_33
+  NWGSEL_B_34 NWGSEL_B_35 NWGSEL_B_36 NWGSEL_B_37 NWGSEL_B_38 NWGSEL_B_39
+  NWGSEL_B_40 NWGSEL_B_41 NWGSEL_B_42 NWGSEL_B_43 NWGSEL_B_44 NWGSEL_B_45
+  NWGSEL_B_46 NWGSEL_B_47 NWGSEL_B_48 NWGSEL_B_49 NWGSEL_B_50 NWGSEL_B_51
+  NWGSEL_B_52 NWGSEL_B_53 NWGSEL_B_54 NWGSEL_B_55 NWGSEL_B_56 NWGSEL_B_57
+  NWGSEL_B_58 NWGSEL_B_59 NWGSEL_B_60 NWGSEL_B_61 NWGSEL_B_62 NWGSEL_B_63
+  NXPDEC1_A[0] NXPDEC1_B[0] NXPDEC1_A[1] NXPDEC1_B[1] NXPDEC1_A[2]
+  NXPDEC1_B[2] NXPDEC1_A[3] NXPDEC1_B[3] NXPDEC1_A[4] NXPDEC1_B[4]
+  NXPDEC1_A[5] NXPDEC1_B[5] NXPDEC1_A[6] NXPDEC1_B[6] NXPDEC1_A[7]
+  NXPDEC1_B[7] NXPDEC2_A[0] NXPDEC2_B[0] NXPDEC2_A[1] NXPDEC2_B[1]
+  NXPDEC2_A[2] NXPDEC2_B[2] NXPDEC2_A[3] NXPDEC2_B[3] NXPDEC2_A[4]
+  NXPDEC2_B[4] NXPDEC2_A[5] NXPDEC2_B[5] NXPDEC2_A[6] NXPDEC2_B[6]
+  NXPDEC2_A[7] NXPDEC2_B[7] NXPDEC3_A[0] NXPDEC3_B[0] NXPDEC3_A[1]
+  NXPDEC3_B[1] NXPDEC3_A[2] NXPDEC3_B[2] NXPDEC3_A[3] NXPDEC3_B[3] PENSOA
+  PENSOB PSOA[0] PSOA[1] PSOB[0] PSOB[1] QA[24] QA[25] QA[26] QA[27] QA[28]
+  QA[29] QA[30] QA[31] QA[32] QA[33] QA[34] QA[35] QA[36] QA[37] QA[38]
+  QA[39] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5] QA[6] QA[7] QA[8] QA[9] QA[10]
+  QA[11] QA[12] QA[13] QA[14] QA[15] QA[16] QA[17] QA[18] QA[19] QA[20]
+  QA[21] QA[22] QA[23] QA[40] QA[41] QA[42] QA[43] QA[44] QA[45] QA[46]
+  QA[47] QA[48] QA[49] QA[50] QA[51] QA[52] QA[53] QA[54] QA[55] QA[56]
+  QA[57] QA[58] QA[59] QA[60] QA[61] QA[62] QA[63] QB[24] QB[25] QB[26]
+  QB[27] QB[28] QB[29] QB[30] QB[31] QB[32] QB[33] QB[34] QB[35] QB[36]
+  QB[37] QB[38] QB[39] QB[0] QB[1] QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8]
+  QB[9] QB[10] QB[11] QB[12] QB[13] QB[14] QB[15] QB[16] QB[17] QB[18] QB[19]
+  QB[20] QB[21] QB[22] QB[23] QB[40] QB[41] QB[42] QB[43] QB[44] QB[45]
+  QB[46] QB[47] QB[48] QB[49] QB[50] QB[51] QB[52] QB[53] QB[54] QB[55]
+  QB[56] QB[57] QB[58] QB[59] QB[60] QB[61] QB[62] QB[63] AA[2] AA[3] AA[4]
+  AA[5] AA[6] AA[7] AB[2] AB[3] AB[4] AB[5] AB[6] AB[7] GDL_A_0 GDL_A_1
+  GDL_A_2 GDL_A_3 GDL_A_4 GDL_A_5 GDL_A_6 GDL_A_7 GDL_A_8 GDL_A_9 GDL_A_10
+  GDL_A_11 GDL_A_12 GDL_A_13 GDL_A_14 GDL_A_15 GDL_A_16 GDL_A_17 GDL_A_18
+  GDL_A_19 GDL_A_20 GDL_A_21 GDL_A_22 GDL_A_23 GDL_A_24 GDL_A_25 GDL_A_26
+  GDL_A_27 GDL_A_28 GDL_A_29 GDL_A_30 GDL_A_31 GDL_A_32 GDL_A_33 GDL_A_34
+  GDL_A_35 GDL_A_36 GDL_A_37 GDL_A_38 GDL_A_39 GDL_A_40 GDL_A_41 GDL_A_42
+  GDL_A_43 GDL_A_44 GDL_A_45 GDL_A_46 GDL_A_47 GDL_A_48 GDL_A_49 GDL_A_50
+  GDL_A_51 GDL_A_52 GDL_A_53 GDL_A_54 GDL_A_55 GDL_A_56 GDL_A_57 GDL_A_58
+  GDL_A_59 GDL_A_60 GDL_A_61 GDL_A_62 GDL_A_63 GDL_B_0 GDL_B_1 GDL_B_2
+  GDL_B_3 GDL_B_4 GDL_B_5 GDL_B_6 GDL_B_7 GDL_B_8 GDL_B_9 GDL_B_10 GDL_B_11
+  GDL_B_12 GDL_B_13 GDL_B_14 GDL_B_15 GDL_B_16 GDL_B_17 GDL_B_18 GDL_B_19
+  GDL_B_20 GDL_B_21 GDL_B_22 GDL_B_23 GDL_B_24 GDL_B_25 GDL_B_26 GDL_B_27
+  GDL_B_28 GDL_B_29 GDL_B_30 GDL_B_31 GDL_B_32 GDL_B_33 GDL_B_34 GDL_B_35
+  GDL_B_36 GDL_B_37 GDL_B_38 GDL_B_39 GDL_B_40 GDL_B_41 GDL_B_42 GDL_B_43
+  GDL_B_44 GDL_B_45 GDL_B_46 GDL_B_47 GDL_B_48 GDL_B_49 GDL_B_50 GDL_B_51
+  GDL_B_52 GDL_B_53 GDL_B_54 GDL_B_55 GDL_B_56 GDL_B_57 GDL_B_58 GDL_B_59
+  GDL_B_60 GDL_B_61 GDL_B_62 GDL_B_63 AYA[2] AYA[3] AYA[4] AYA[5] AYA[6]
+  AYA[7] RAYA[6] RAYA[7] RAYA[8] AYB[2] AYB[3] AYB[4] AYB[5] AYB[6] AYB[7]
+  RAYB[6] RAYB[7] RAYB[8] RET1N RETA[1] RETB[0] RE_A RE_B SEA SEB SIA[0]
+  SIA[1] SIB[0] SIB[1] SOA[0] SOA[1] SOB[0] SOB[1] TAA[0] TAA[1] TAB[0]
+  TAB[1] TCENA TCENB TDA[24] TDA[25] TDA[26] TDA[27] TDA[28] TDA[29] TDA[30]
+  TDA[31] TDA[32] TDA[33] TDA[34] TDA[35] TDA[36] TDA[37] TDA[38] TDA[39]
+  TDA[0] TDA[1] TDA[2] TDA[3] TDA[4] TDA[5] TDA[6] TDA[7] TDA[8] TDA[9]
+  TDA[10] TDA[11] TDA[12] TDA[13] TDA[14] TDA[15] TDA[16] TDA[17] TDA[18]
+  TDA[19] TDA[20] TDA[21] TDA[22] TDA[23] TDA[40] TDA[41] TDA[42] TDA[43]
+  TDA[44] TDA[45] TDA[46] TDA[47] TDA[48] TDA[49] TDA[50] TDA[51] TDA[52]
+  TDA[53] TDA[54] TDA[55] TDA[56] TDA[57] TDA[58] TDA[59] TDA[60] TDA[61]
+  TDA[62] TDA[63] TDB[24] TDB[25] TDB[26] TDB[27] TDB[28] TDB[29] TDB[30]
+  TDB[31] TDB[32] TDB[33] TDB[34] TDB[35] TDB[36] TDB[37] TDB[38] TDB[39]
+  TDB[0] TDB[1] TDB[2] TDB[3] TDB[4] TDB[5] TDB[6] TDB[7] TDB[8] TDB[9]
+  TDB[10] TDB[11] TDB[12] TDB[13] TDB[14] TDB[15] TDB[16] TDB[17] TDB[18]
+  TDB[19] TDB[20] TDB[21] TDB[22] TDB[23] TDB[40] TDB[41] TDB[42] TDB[43]
+  TDB[44] TDB[45] TDB[46] TDB[47] TDB[48] TDB[49] TDB[50] TDB[51] TDB[52]
+  TDB[53] TDB[54] TDB[55] TDB[56] TDB[57] TDB[58] TDB[59] TDB[60] TDB[61]
+  TDB[62] TDB[63] TENA TENB TWENA TWENB TAA[2] TAA[3] TAA[4] TAA[5] TAA[6]
+  TAA[7] TAB[2] TAB[3] TAB[4] TAB[5] TAB[6] TAB[7] VDDCE VDDPE DATAIN_A_0
+  DATAIN_A_1 DATAIN_A_2 DATAIN_A_3 DATAIN_A_4 DATAIN_A_5 DATAIN_A_6
+  DATAIN_A_7 DATAIN_A_8 DATAIN_A_9 DATAIN_A_10 DATAIN_A_11 DATAIN_A_12
+  DATAIN_A_13 DATAIN_A_14 DATAIN_A_15 DATAIN_A_16 DATAIN_A_17 DATAIN_A_18
+  DATAIN_A_19 DATAIN_A_20 DATAIN_A_21 DATAIN_A_22 DATAIN_A_23 DATAIN_A_24
+  DATAIN_A_25 DATAIN_A_26 DATAIN_A_27 DATAIN_A_28 DATAIN_A_29 DATAIN_A_30
+  DATAIN_A_31 DATAIN_A_32 DATAIN_A_33 DATAIN_A_34 DATAIN_A_35 DATAIN_A_36
+  DATAIN_A_37 DATAIN_A_38 DATAIN_A_39 DATAIN_A_40 DATAIN_A_41 DATAIN_A_42
+  DATAIN_A_43 DATAIN_A_44 DATAIN_A_45 DATAIN_A_46 DATAIN_A_47 DATAIN_A_48
+  DATAIN_A_49 DATAIN_A_50 DATAIN_A_51 DATAIN_A_52 DATAIN_A_53 DATAIN_A_54
+  DATAIN_A_55 DATAIN_A_56 DATAIN_A_57 DATAIN_A_58 DATAIN_A_59 DATAIN_A_60
+  DATAIN_A_61 DATAIN_A_62 DATAIN_A_63 DATAIN_B_0 DATAIN_B_1 DATAIN_B_2
+  DATAIN_B_3 DATAIN_B_4 DATAIN_B_5 DATAIN_B_6 DATAIN_B_7 DATAIN_B_8
+  DATAIN_B_9 DATAIN_B_10 DATAIN_B_11 DATAIN_B_12 DATAIN_B_13 DATAIN_B_14
+  DATAIN_B_15 DATAIN_B_16 DATAIN_B_17 DATAIN_B_18 DATAIN_B_19 DATAIN_B_20
+  DATAIN_B_21 DATAIN_B_22 DATAIN_B_23 DATAIN_B_24 DATAIN_B_25 DATAIN_B_26
+  DATAIN_B_27 DATAIN_B_28 DATAIN_B_29 DATAIN_B_30 DATAIN_B_31 DATAIN_B_32
+  DATAIN_B_33 DATAIN_B_34 DATAIN_B_35 DATAIN_B_36 DATAIN_B_37 DATAIN_B_38
+  DATAIN_B_39 DATAIN_B_40 DATAIN_B_41 DATAIN_B_42 DATAIN_B_43 DATAIN_B_44
+  DATAIN_B_45 DATAIN_B_46 DATAIN_B_47 DATAIN_B_48 DATAIN_B_49 DATAIN_B_50
+  DATAIN_B_51 DATAIN_B_52 DATAIN_B_53 DATAIN_B_54 DATAIN_B_55 DATAIN_B_56
+  DATAIN_B_57 DATAIN_B_58 DATAIN_B_59 DATAIN_B_60 DATAIN_B_61 DATAIN_B_62
+  DATAIN_B_63 WENYA[0] WENYA[1] WENYA[2] WENYA[3] WENYA[4] WENYA[5] WENYA[6]
+  WENYA[7] WENYA[8] WENYA[9] WENYA[10] WENYA[11] WENYA[12] WENYA[13]
+  WENYA[14] WENYA[15] WENYA_0 WENYA_1 WENYA_2 WENYA_3 WENYA_4 WENYA_5 WENYA_6
+  WENYA_7 WENYA_8 WENYA_9 WENYA_10 WENYA_11 WENYA_12 WENYA_13 WENYA_14
+  WENYA_15 WENYA_16 WENYA_17 WENYA_18 WENYA_19 WENYA_20 WENYA_21 WENYA_22
+  WENYA_23 WENYA_24 WENYA_25 WENYA_26 WENYA_27 WENYA_28 WENYA_29 WENYA_30
+  WENYA_31 WENYA_32 WENYA_33 WENYA_34 WENYA_35 WENYA_36 WENYA_37 WENYA_38
+  WENYA_39 WENYA_40 WENYA_41 WENYA_42 WENYA_43 WENYA_44 WENYA_45 WENYA_46
+  WENYA_47 WENYB[0] WENYB[1] WENYB[2] WENYB[3] WENYB[4] WENYB[5] WENYB[6]
+  WENYB[7] WENYB[8] WENYB[9] WENYB[10] WENYB[11] WENYB[12] WENYB[13]
+  WENYB[14] WENYB[15] WENYB_0 WENYB_1 WENYB_2 WENYB_3 WENYB_4 WENYB_5 WENYB_6
+  WENYB_7 WENYB_8 WENYB_9 WENYB_10 WENYB_11 WENYB_12 WENYB_13 WENYB_14
+  WENYB_15 WENYB_16 WENYB_17 WENYB_18 WENYB_19 WENYB_20 WENYB_21 WENYB_22
+  WENYB_23 WENYB_24 WENYB_25 WENYB_26 WENYB_27 WENYB_28 WENYB_29 WENYB_30
+  WENYB_31 WENYB_32 WENYB_33 WENYB_34 WENYB_35 WENYB_36 WENYB_37 WENYB_38
+  WENYB_39 WENYB_40 WENYB_41 WENYB_42 WENYB_43 WENYB_44 WENYB_45 WENYB_46
+  WENYB_47 WE_A WE_B WRA_MA WRB_MA WTE_A WTE_B SRAMdpw64d256IOARRAY64
.ENDS SRAMdpw64d256
